<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\serial_bootloader_flash.ewp</path>
	</project>
</workspace>
