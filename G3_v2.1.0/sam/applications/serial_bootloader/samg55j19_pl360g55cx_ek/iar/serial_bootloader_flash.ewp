# IAR project serial_bootloader_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAMG55J19 Atmel SAMG55J19
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=PL360G55CF_EK; __SAMG55J19__; ARM_MATH_CM4=true; UDD_ENABLE
  ICCARM.CCIncludePath2: ..\..\..\..\utils\fpu; ..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\common\services\usb\class\cdc\device; ..\..\..\..\utils\cmsis\samg\samg55\include; ..\..\..\..\utils; ..\..\..\..\..\common\services\usb; ..\..\..\..\drivers\udp; ..\..\..\..\..\common\boards; ..\..\..\..\..\common\services\usb\udc; ..\..\..\..\boards\pl360g55cf_ek; ..\..\..\..\boards; ..\..\..\..\drivers\pmc; ..\..\..\..\utils\cmsis\samg\samg55\source\templates; ..\..\..\..\utils\preprocessor; ..\..\..\..\..\common\utils; ..\..\..\..\..\common\services\delay; ..\..\..\..\..\common\services\usb\class\cdc; ..\..\..\..\drivers\pio; ..\..\..\..\drivers\efc; ..\..\..\..\drivers\supc; ..\..\..\..\..\common\services\clock; ..\..\..\..\drivers\flexcom; ..\..\..\..\..\common\services\gpio; ..\..\..\..\drivers\matrix; ..\..\..\..\utils\header_files; ..\..\..\..\services\flash_efc; ..; ..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: serial_bootloader_flash.bin
  ILINK.IlinkOutputFile: serial_bootloader_flash.out
  ILINK.IlinkIcfFile: ..\..\linker_scripts\iar\samg_flash_bootloader.icf
  ILINK.IlinkExtraOptions: --config_def __ICFEDIT_size_cstack__=0x400
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group common/services/clock
    ../../../../../common/services/clock/: pll.h genclk.h osc.h sysclk.h
  group common/services/clock/samg
    ../../../../../common/services/clock/samg/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/usb
    ../../../../../common/services/usb/: usb_protocol.h usb_atmel.h
  group common/services/usb/udc
    ../../../../../common/services/usb/udc/: udc.c udc.h udi.h udd.h udc_desc.h
  group common/services/usb/class/cdc
    ../../../../../common/services/usb/class/cdc/: usb_protocol_cdc.h
  group common/services/usb/class/cdc/device
    ../../../../../common/services/usb/class/cdc/device/: udi_cdc_desc.c udi_cdc.c udi_cdc.h udi_cdc_conf.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/services/gpio
    ../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/applications/serial_bootloader
    ../../: main.c serial_monitor.c usart_serial.c usart_serial.h main.h serial_monitor.h
  group sam/applications/serial_bootloader/samg55j19_pl360g55cx_ek
    ../: conf_clock.h conf_usb.h conf_sleepmgr.h conf_board.h conf_bootloader.h
  group sam/applications/serial_bootloader/samg55j19_pl360g55cx_ek/iar
    ./: asf.h
  group sam/services/flash_efc
    ../../../../services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pmc
    ../../../../drivers/pmc/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/efc
    ../../../../drivers/efc/: efc.c efc.h
  group sam/drivers/matrix
    ../../../../drivers/matrix/: matrix.c matrix.h
  group sam/drivers/udp
    ../../../../drivers/udp/: udp_device.c udp_device.h
  group sam/drivers/pio
    ../../../../drivers/pio/: pio_handler.c pio.c pio.h pio_handler.h
  group sam/drivers/usart
    ../../../../drivers/usart/: usart.c usart.h
  group sam/drivers/supc
    ../../../../drivers/supc/: supc.c supc.h
  group sam/drivers/flexcom
    ../../../../drivers/flexcom/: flexcom.c flexcom.h
  group sam/utils
    ../../../../utils/: status_codes.h compiler.h
  group sam/utils/cmsis/samg/samg55/source/templates
    ../../../../utils/cmsis/samg/samg55/source/templates/: system_samg55.c
  group sam/utils/cmsis/samg/samg55/source/templates/iar
    ../../../../utils/cmsis/samg/samg55/source/templates/iar/: startup_samg55.c
  group sam/utils/cmsis/samg/samg55/include
    ../../../../utils/cmsis/samg/samg55/include/: samg55g19.h samg55n19.h samg55j19.h samg55.h samg55j18.h samg55g18.h system_samg55.h
  group sam/utils/cmsis/samg/samg55/include/component
    ../../../../utils/cmsis/samg/samg55/include/component/: mem2mem.h gpbr.h pio.h crccu.h uhp.h cmcc.h pmc.h chipid.h twi.h pdmic.h spi.h rtt.h rtc.h efc.h wdt.h supc.h flexcom.h matrix.h rstc.h i2sc.h tc.h adc.h pdc.h udp.h usart.h
  group sam/utils/cmsis/samg/samg55/include/instance
    ../../../../utils/cmsis/samg/samg55/include/instance/: gpbr.h piob.h matrix.h twi7.h pdmic1.h twi5.h flexcom4.h tc1.h flexcom2.h twi6.h adc.h flexcom6.h twi1.h twi3.h twi4.h efc.h cmcc.h supc.h pdmic0.h usart1.h flexcom3.h spi2.h flexcom0.h flexcom7.h spi6.h flexcom1.h spi4.h i2sc0.h wdt.h spi0.h rtc.h chipid.h usart3.h flexcom5.h i2sc1.h spi3.h spi5.h udp.h crccu.h usart7.h mem2mem.h pmc.h rtt.h uhp.h usart4.h pioa.h usart2.h spi7.h spi1.h twi0.h tc0.h usart5.h usart6.h rstc.h twi2.h usart0.h
  group sam/utils/cmsis/samg/samg55/include/pio
    ../../../../utils/cmsis/samg/samg55/include/pio/: samg55g19.h samg55j18.h samg55g18.h samg55j19.h samg55n19.h
  group sam/utils/preprocessor
    ../../../../utils/preprocessor/: mrepeat.h preprocessor.h stringz.h tpaste.h
  group sam/utils/fpu
    ../../../../utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../utils/header_files/: io.h
  group sam/boards/pl360g55cf_ek
    ../../../../boards/pl360g55cf_ek/: init.c led.h pl360g55cf_ek.h
