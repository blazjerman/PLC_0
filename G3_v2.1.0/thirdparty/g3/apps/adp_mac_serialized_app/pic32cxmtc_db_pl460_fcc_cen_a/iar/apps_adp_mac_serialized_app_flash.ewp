# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTC128 Microchip PIC32CX2051MTC128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __G3_STACK__; BOARD=PIC32CXMTC_DB; __PIC32CX2051MTC128__; __FREERTOS__; ARM_MATH_CM4=true; __PLC_MAC__
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\adp\include; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\mac_common\include; ..\..\..; ..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\utils; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\routing_loadng\source; ..\..\..\..\routing_wrapper\include; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\mac\include; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\pal\atpl360_g3macrt\include; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\oss; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\common\include; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\mbed-tls\include; ..; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-adp.a
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbpDev.c ProcessLbpCoord.c ProtoEapPsk.c ProtoLbp.c ProtoEapPsk.h ProtoLbpVersion.h ProtoLbp.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: LbpDefs.h ProcessLbpDev.h ProcessLbpCoord.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c brg_types.h cipher_wrapper.h aes_wrapper.h eax.h mode_hdr.h brg_endian.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_mib_common.c serial_if_mac.h serial_if_adp.h serial_if_common.h serial_if_mib_common.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup007_cen_a.h pl460_1_5b_fcc.h pl460_sb_fcc.h pl460_plcoup007_cen_a.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Timer.c Random.c Logger.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Timer.h QueueMng.h Logger.h Random.h g3_stack_version.h
  group thirdparty/g3/pal/atpl360_g3macrt/source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty/g3/pal/atpl360_g3macrt/include
    ../../../../pal/atpl360_g3macrt/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/pic32cxmtc_db_pl460_fcc_cen_a
    ../: conf_busart_if.h conf_project.h conf_cl010_slcdc.h conf_usi.h conf_oss.h conf_clock.h conf_tables.h conf_buart_if.h conf_atpl360.h conf_sleepmgr.h conf_pplc_if.h conf_board.h FreeRTOSConfig.h conf_bs.h conf_hal.h conf_slcdc.h conf_uart_serial.h
  group thirdparty/g3/apps/adp_mac_serialized_app/pic32cxmtc_db_pl460_fcc_cen_a/iar
    ./: asf.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/mac_common/source
    ../../../../mac_common/source/: MacCommon.c
  group thirdparty/g3/mac_common/include
    ../../../../mac_common/include/: MacCommonDefs.h MacCommon.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtDefs.h MacRtMib.h MacRt.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacDefs.h MacApi.h MacMib.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c memory_buffer_alloc.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c aesni.h cipher_wrap.h common.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: base64.h memory_buffer_alloc.h version.h build_info.h gcm.h entropy.h md.h timing.h ctr_drbg.h ccm.h cmac.h error.h asn1.h aes.h bignum.h threading.h debug.h cipher.h pk.h oid.h private_access.h compat-2.x.h mbedtls_config.h platform_time.h check_config.h ssl.h sha256.h ssl_ciphersuites.h ecp.h platform.h platform_util.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: timers.c FreeRTOS_CLI.c list.c queue.c tasks.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: portable.h projdefs.h queue.h FreeRTOS.h list.h mpu_wrappers.h FreeRTOS_CLI.h timers.h StackMacros.h croutine.h task.h semphr.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/sfr
    ../../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_segmap.h cl010.h cl010_font.h
  group sam/boards/pic32cxmtc_db
    ../../../../../../sam/boards/pic32cxmtc_db/: init.c pic32cxmtc_db.h led.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtc128S1.h pic32cxmt.h pic32cx2051mtsh128S1.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128S1.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h system_pic32cxmt.h pic32cx5112mtsh128.h pic32cx5112mtc128.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h usart5.h spi7.h twi0.h pmc.h tc0.h cmcc0.h ipc1.h usart7.h pwm.h spi5.h twi2.h flexcom6.h twi4.h spi4.h rstc.h trng.h ipc0.h usart0.h usart6.h sha.h emafe.h sfr.h icm.h usart2.h sfrbu.h twi6.h spi3.h cpkcc.h twi7.h matrix0.h spi1.h usart3.h gpbr.h pio.h slcdc.h flexcom0.h tc2.h flexcom2.h usart1.h rtc.h cmcc1.h acc.h qspi.h sefc1.h adc.h flexcom5.h spi2.h matrix3.h syscwp.h twi1.h aes.h matrix1.h spi0.h twi5.h supc.h tc3.h flexcom1.h tc1.h aesb.h flexcom3.h rtt.h usart4.h sefc0.h uart.h chipid.h matrix2.h spi6.h twi3.h mcspi.h flexcom7.h mem2mem0.h dwdt.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: sfr.h rtt.h mem2mem.h emafe.h syscwp.h twi.h supc.h qspi.h rstc.h slcdc.h ipc.h pdc.h acc.h uart.h trng.h cmcc.h mcspi.h tc.h aes.h dwdt.h icm.h pio.h spi.h cpkcc.h adc.h chipid.h matrix.h gpbr.h pwm.h rtc.h sha.h pmc.h aesb.h sfrbu.h flexcom.h sefc.h usart.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx5112mtsh128.h pic32cx1025mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx2051mtg64.h pic32cx5112mtc128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtc128.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c atpl360_boot.h atpl360.h atpl360_exception.h atpl360_hal_spi.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
