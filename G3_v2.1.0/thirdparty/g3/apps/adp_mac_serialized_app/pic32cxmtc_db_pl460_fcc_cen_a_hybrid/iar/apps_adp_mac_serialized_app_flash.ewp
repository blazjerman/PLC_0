# IAR project apps_adp_mac_serialized_app_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTC128 Microchip PIC32CX2051MTC128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __G3_STACK__; BOARD=PIC32CXMTC_DB; __RF_MAC__; __PIC32CX2051MTC128__; __FREERTOS__; ARM_MATH_CM4=true; __PLC_MAC__
  ICCARM.CCIncludePath2: ..\..\..\..\routing_wrapper\source; ..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\common\services\ioport; ..\..; ..\..\..\..\..\freertos\freertos-7.3.0\source\include; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\common\utils; ..\..\..\..\pal\atpl360_g3macrt\include; ..\..\..\..\pal_rf\rf215_g3mac\include; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3; ..\..\..\..\..\mbed-tls\include; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\coordinator\source; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\coordinator\include; ..\..\..\..\..\..\sam\utils; ..\..\..\..\routing_loadng\source; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\mac_rf\include; ..\..\..\..\oss; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..; ..\..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\adp\include; ..\..\..\..\mac\include; ..\..\..; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f; ..\..\..\..\routing_wrapper\include; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..\..\..\addons\serial_if_adp_mac; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\bootstrap_lbp\include; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\mac_common\include; ..\..\..\..\..\..\common\boards; ..\..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\routing_loadng\include; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\bootstrap_lbp\source; ..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\..\mbed-tls\library; ..\..\..\..\common\source; ..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\common\services\clock; ..; ..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\common\include; ..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\mac_wrapper\include; ..\..\..\..\..\..\sam\drivers\usart; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_adp_mac_serialized_app_flash.bin
  ILINK.IlinkOutputFile: apps_adp_mac_serialized_app_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group thirdparty/g3/libs/iar
    ../../../../libs/iar/: lib-g3-iar-loadng.a lib-g3-iar-mac.a lib-g3-iar-mac-rf.a lib-g3-iar-adp.a
  group thirdparty/g3/pal_rf/rf215_g3mac/source
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty/g3/pal_rf/rf215_g3mac/include
    ../../../../pal_rf/rf215_g3mac/include/: pal_rf.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../bootstrap_lbp/source/: ProcessLbpDev.c ProcessLbpCoord.c ProtoEapPsk.c ProtoLbp.c ProtoLbp.h ProtoLbpVersion.h ProtoEapPsk.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../bootstrap_lbp/include/: ProcessLbpDev.h ProcessLbpCoord.h LbpDefs.h
  group thirdparty/g3/crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c cipher_wrapper.h brg_types.h brg_endian.h eax.h aes_wrapper.h mode_hdr.h
  group thirdparty/g3/coordinator/source
    ../../../../coordinator/source/: bs_functions.c bs_main.c bs_functions.h
  group thirdparty/g3/coordinator/include
    ../../../../coordinator/include/: bs_api.h
  group thirdparty/g3/addons/serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_mib_common.c serial_if_mac.h serial_if_mib_common.h serial_if_common.h serial_if_adp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: pl460_sb_fcc.h pl460_plcoup007_cen_a.h plcoup007_cen_a.h pl460_1_5b_fcc.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/hal
    ../../../../hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/common/source
    ../../../../common/source/: Timer.c Random.c Logger.c QueueMng.c
  group thirdparty/g3/common/include
    ../../../../common/include/: Timer.h Logger.h Random.h QueueMng.h g3_stack_version.h
  group thirdparty/g3/pal/atpl360_g3macrt/source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty/g3/pal/atpl360_g3macrt/include
    ../../../../pal/atpl360_g3macrt/include/: pal.h
  group thirdparty/g3/apps
    ../../../: conf_global.h
  group thirdparty/g3/apps/adp_mac_serialized_app
    ../../: main.c
  group thirdparty/g3/apps/adp_mac_serialized_app/pic32cxmtc_db_pl460_fcc_cen_a_hybrid
    ../: conf_cl010_slcdc.h conf_tables.h conf_at86rf.h conf_timer_1us.h conf_busart_if.h conf_prf_if.h conf_buart_if.h conf_usi.h conf_hal.h conf_project.h conf_atpl360.h FreeRTOSConfig.h conf_clock.h conf_sleepmgr.h conf_pplc_if.h conf_bs.h conf_oss.h conf_slcdc.h conf_board.h conf_uart_serial.h
  group thirdparty/g3/apps/adp_mac_serialized_app/pic32cxmtc_db_pl460_fcc_cen_a_hybrid/iar
    ./: asf.h
  group thirdparty/g3/oss
    ../../../../oss/: oss_if.c oss_if.h
  group thirdparty/g3/adp
    ../../../../adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../adp/include/: AdpApiTypes.h AdpSharedTypes.h AdpApi.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../routing_wrapper/include/: RoutingApi.h RoutingTypes.h
  group thirdparty/g3/mac_common/source
    ../../../../mac_common/source/: MacCommon.c
  group thirdparty/g3/mac_common/include
    ../../../../mac_common/include/: MacCommonDefs.h MacCommon.h
  group thirdparty/g3/storage
    ../../../../storage/: storage.c storage.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../mac_wrapper/include/: mac_wrapper.h mac_wrapper_defs.h
  group thirdparty/g3/mac/include
    ../../../../mac/include/: MacApi.h MacMib.h MacDefs.h
  group thirdparty/g3/routing_loadng/include
    ../../../../routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/g3/mac_rf/include
    ../../../../mac_rf/include/: MacRfDefs.h MacRfApi.h MacRfMib.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtConstants.h MacRtDefs.h MacRtMib.h MacRt.h
  group thirdparty/mbed-tls/library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c memory_buffer_alloc.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c cipher_wrap.h common.h aesni.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../../mbed-tls/include/mbedtls/: ctr_drbg.h cmac.h pk.h cipher.h entropy.h timing.h error.h ssl_ciphersuites.h build_info.h compat-2.x.h ccm.h md.h base64.h asn1.h mbedtls_config.h bignum.h platform.h platform_time.h ecp.h platform_util.h memory_buffer_alloc.h gcm.h version.h aes.h sha256.h threading.h debug.h oid.h private_access.h check_config.h ssl.h
  group thirdparty/freertos/freertos-7.3.0/source
    ../../../../../freertos/freertos-7.3.0/source/: timers.c FreeRTOS_CLI.c list.c tasks.c queue.c
  group thirdparty/freertos/freertos-7.3.0/source/portable/iar/sam_cm4f
    ../../../../../freertos/freertos-7.3.0/source/portable/iar/sam_cm4f/: port.c portasm.s portmacro.h
  group thirdparty/freertos/freertos-7.3.0/source/portable/memmang
    ../../../../../freertos/freertos-7.3.0/source/portable/memmang/: heap_4.c
  group thirdparty/freertos/freertos-7.3.0/source/include
    ../../../../../freertos/freertos-7.3.0/source/include/: mpu_wrappers.h task.h portable.h projdefs.h queue.h StackMacros.h semphr.h FreeRTOS_CLI.h timers.h list.h croutine.h FreeRTOS.h
  group sam/services/plc/buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/services/timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/sfr
    ../../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/aes
    ../../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/boards/pic32cxmtc_db
    ../../../../../../sam/boards/pic32cxmtc_db/: init.c pic32cxmtc_db.h led.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx5112mtsh128.h pic32cx2051mtc128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx1025mtg64.h system_pic32cxmt.h pic32cx5112mtsh128S1.h pic32cx5112mtc128.h pic32cx2051mtg64.h pic32cx1025mtsh128S1.h pic32cx2051mtg128.h pic32cx2051mtsh128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx1025mtc128.h pic32cx1025mtc128S1.h pic32cxmt.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h spi7.h flexcom2.h cmcc0.h flexcom0.h spi5.h flexcom6.h mem2mem0.h trng.h sfr.h spi3.h spi1.h pio.h rtc.h syscwp.h sefc1.h supc.h aesb.h usart4.h twi0.h usart6.h twi6.h pmc.h ipc1.h twi2.h twi4.h usart0.h usart2.h tc0.h matrix2.h matrix0.h cpkcc.h tc2.h cmcc1.h adc.h flexcom5.h spi4.h flexcom3.h flexcom1.h chipid.h flexcom7.h mem2mem1.h mcspi.h sefc0.h emafe.h qspi.h spi2.h twi1.h spi0.h twi5.h uart.h twi7.h rtt.h spi6.h twi3.h usart7.h rstc.h ipc0.h sha.h aes.h sfrbu.h gpbr.h usart1.h slcdc.h usart3.h acc.h tc1.h matrix3.h matrix1.h dwdt.h usart5.h tc3.h pwm.h icm.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: rtc.h slcdc.h cmcc.h adc.h syscwp.h matrix.h rtt.h twi.h supc.h pdc.h pwm.h aesb.h flexcom.h sfr.h emafe.h pmc.h rstc.h acc.h uart.h trng.h mcspi.h aes.h pio.h sefc.h tc.h qspi.h ipc.h dwdt.h icm.h spi.h gpbr.h usart.h sha.h chipid.h mem2mem.h cpkcc.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtsh128.h pic32cx1025mtg128.h pic32cx1025mtc128.h pic32cx5112mtc128.h pic32cx1025mtg64.h pic32cx5112mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx2051mtg64.h pic32cx2051mtsh128.h pic32cx2051mtc128.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h tpaste.h stringz.h mrepeat.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group common/components/rf/at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h ieee_15_4_sun_ofdm.h at86rf_version.h at86rf.h at86rf_defs.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq_defs.h rf215_irq.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c rf215_trx_ctl.h rf215_spi.h rf215_conf_check.h rf215_phy_defs.h rf215_reg.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c rf215_tx_rx.h rf215_tx_rx_defs.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll.h rf215_pll_defs.h
  group common/components/rf/at86rf215/addons
    ../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common/components/rf/at86rf215/addons/sniffer_if/g3
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c rf215_sniffer_if.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c atpl360.h atpl360_exception.h atpl360_boot.h atpl360_hal_spi.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/utils
    ../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../common/services/clock/: osc.h sysclk.h pll.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/boards
    ../../../../../../common/boards/: board.h
