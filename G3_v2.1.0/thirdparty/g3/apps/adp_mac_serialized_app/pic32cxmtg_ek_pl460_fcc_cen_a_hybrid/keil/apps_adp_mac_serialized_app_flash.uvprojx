# Keil uVision project apps_adp_mac_serialized_app_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTG128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x8C000) IROM(0x01000000,0x200000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __G3_STACK__ BOARD=PIC32CXMTG_EK __PIC32CX2051MTG128__ __RF_MAC__ __FREERTOS__ ARM_MATH_CM4=true __PLC_MAC__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\adp\include;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\mac_common\include;..\..\..;..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\routing_wrapper\include;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\..\..\common\services\serial;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\addons\serial_if_adp_mac;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\ioport;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\..\..\common\boards;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\pal_rf\rf215_g3mac\include;..\..\..\..\common\source;..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\mac\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\oss;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\common\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\..\sam\drivers\sfr;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\..\sam\boards\pic32cxmtg_ek;..\..\..\..\coordinator\source;..\..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\mac_rf\include;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8C000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-mac-rf.lib lib-g3-keil-adp.lib
  group thirdparty_g3_pal_rf_rf215_g3mac_source
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbpDev.c ProcessLbpCoord.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c eax.c cipher_wrapper.c
  group thirdparty_g3_coordinator_source
    ../../../../coordinator/source/: bs_functions.c bs_main.c
  group thirdparty_g3_addons_serial_if_adp_mac
    ../../../../addons/serial_if_adp_mac/: serial_if_common.c serial_if_mac.c serial_if_adp.c serial_if_mib_common.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Timer.c Random.c Logger.c QueueMng.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_apps_adp_mac_serialized_app
    ../../: main.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_mac_common_source
    ../../../../mac_common/source/: MacCommon.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_mbed-tls_library
    ../../../../../mbed-tls/library/: cipher.c aesni.c error.c ccm.c memory_buffer_alloc.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group thirdparty_mbed-tls_sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_services_timer_1us_hal_pic32cx
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam_services_timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pmc_pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_pio_pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_sfr
    ../../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_supc_pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_aes
    ../../../../../../sam/drivers/aes/: aes.c
  group sam_boards_pic32cxmtg_ek
    ../../../../../../sam/boards/pic32cxmtg_ek/: init.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_rf_at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_addons_sniffer_if_g3
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
  group common_components_rf_at86rf215_addons_sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
