<?xml version="1.0" encoding="iso-8859-1"?>

<workspace>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl360g55cb_ek\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl360g55cb_ek_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl360g55cb_ek\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl360g55cb_ek_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl360g55cb_ek\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl360g55cb_ek_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_meter\samg55j19_pl360g55cb_ek\iar\apps_dlms_app_meter_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_modem\samg55j19_pl360g55cb_ek\iar\apps_dlms_app_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55j19_pl360g55cb_ek\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55j19_pl360g55cb_ek\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55j19_pl360g55cb_ek\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55j19_pl360g55cb_ek_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55j19_pl360g55cb_ek\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55j19_pl360g55cb_ek_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55j19_pl360g55cb_ek\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl360g55cf_ek\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl360g55cf_ek_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl360g55cf_ek\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl360g55cf_ek_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl360g55cf_ek\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl360g55cf_ek_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_meter\samg55j19_pl360g55cf_ek\iar\apps_dlms_app_meter_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_modem\samg55j19_pl360g55cf_ek\iar\apps_dlms_app_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55j19_pl360g55cf_ek\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55j19_pl360g55cf_ek\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55j19_pl360g55cf_ek\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55j19_pl360g55cf_ek_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55j19_pl360g55cf_ek\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55j19_pl360g55cf_ek_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55j19_pl360g55cf_ek\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\..\sam\applications\serial_bootloader\samg55j19_pl360g55cx_ek\iar\serial_bootloader_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_cen_b\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_cen_b_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_fcc\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_fcc_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtsh_db_pl460_fcc_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_cen_b\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_cen_b_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtsh_db_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtsh_db_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtsh_db_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtsh_db_pl460_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtsh_db_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtsh_db_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtsh_db_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtsh_db_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtsh_db_pl460_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtsh_db_pl460_cen_b_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtsh_db_pl460_fcc_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtsh_db_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtsh_db_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtsh_db_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70q21_pl360bn_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70q21_pl360bn_cen_b_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70q21_pl360bn_fcc_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70q21_pl360bn_cen_a_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70q21_pl360bn_cen_b_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70q21_pl360bn_fcc_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70q21_pl360bn_multiband_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70q21_pl360bn_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70q21_pl360bn_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70q21_pl360bn_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70q21_pl360bn_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70q21_pl360bn_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70q21_pl360bn_fcc\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70q21_pl360bn_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70q21_pl360bn_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70q21_pl360bn_fcc\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70q21_pl360bn_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70q21_pl360bn_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70q21_pl360bn_fcc\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_cen_b\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_cen_b_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_fcc\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_fcc_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtc_db_pl460_fcc_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtc_db_pl460_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtc_db_pl460_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtc_db_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtc_db_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtc_db_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtc_db_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtc_db_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtc_db_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtc_db_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtc_db_pl460_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtc_db_pl460_cen_b_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtc_db_pl460_fcc_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtc_db_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtc_db_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtc_db_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_cen_b\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_cen_b_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_fcc\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_fcc_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\pic32cxmtg_ek_pl460_fcc_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_cen_a\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_cen_a_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_cen_b\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_cen_b_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\pic32cxmtg_ek_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_cen_b\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_cen_b_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\pic32cxmtg_ek_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtg_ek_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtg_ek_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtg_ek_pl460_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtg_ek_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtg_ek_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\pic32cxmtg_ek_pl460_cen_a\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\pic32cxmtg_ek_pl460_cen_b\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\pic32cxmtg_ek_pl460_fcc\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\pic32cxmtg_ek_pl460_cen_a_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\pic32cxmtg_ek_pl460_cen_b_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\pic32cxmtg_ek_pl460_fcc_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtg_ek_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtg_ek_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtg_ek_pl460_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtg_ek_pl460_cen_b_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\pic32cxmtg_ek_pl460_fcc_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtg_ek_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtg_ek_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\pic32cxmtg_ek_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms_db_pl460_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms_db_pl460_cen_b_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms_db_pl460_fcc_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms_db_pl460_fcc_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms_db_pl460_cen_a_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms_db_pl460_cen_b_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms_db_pl460_fcc_cen_a_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms_db_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms_db_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms_db_pl460_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms_db_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms_db_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms_db_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms_db_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms_db_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms_db_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms_db_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms_db_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms_db_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms_db_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70_xplained_pl460_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70_xplained_pl460_cen_b_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70_xplained_pl460_fcc_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\same70_xplained_pl460_fcc_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70_xplained_pl460_cen_a_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70_xplained_pl460_cen_b_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70_xplained_pl460_fcc_cen_a_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\same70_xplained_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70_xplained_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70_xplained_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70_xplained_pl460_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\same70_xplained_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70_xplained_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70_xplained_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\same70_xplained_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70_xplained_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70_xplained_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\same70_xplained_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70_xplained_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70_xplained_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\same70_xplained_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_cen_b\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_fcc\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_fcc_cen_a\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_cen_a\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_cen_b\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_fcc_cen_a\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_cen_b\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_fcc_cen_a\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55_xplained_pl460_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55_xplained_pl460_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55_xplained_pl460_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\samg55_xplained_pl460_fcc_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55_xplained_pl460_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55_xplained_pl460_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55_xplained_pl460_fcc_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55_xplained_pl460_cen_a\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55_xplained_pl460_cen_b\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55_xplained_pl460_fcc\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55_xplained_pl460_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55_xplained_pl460_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55_xplained_pl460_fcc_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55_xplained_pl460_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55_xplained_pl460_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55_xplained_pl460_fcc_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl485_ek_cenb\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55j19_pl485_ek_cenb_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl485_ek_cenb\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55j19_pl485_ek_cenb_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl485_ek_cenb\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55j19_pl485_ek_cenb_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\samg55j19_pl485_ek_cenb\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\samg55j19_pl485_ek_cenb\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55j19_pl485_ek_cenb_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\samg55j19_pl485_ek_cenb\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55j19_pl485_ek_cenb_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\samg55j19_pl485_ek_cenb\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_cen_b_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_fcc_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\samg55_xplained_pl460_fcc_cen_a_hybrid\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_cen_a_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_cen_b_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_fcc_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\samg55_xplained_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_cen_b_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_fcc_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\samg55_xplained_pl460_fcc_cen_a_hybrid\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55_xplained_pl460_cen_a_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55_xplained_pl460_cen_b_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_hybrid_tool\samg55_xplained_pl460_fcc_hybrid\iar\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55_xplained_pl460_cen_a_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55_xplained_pl460_cen_b_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_hybrid_tool\samg55_xplained_pl460_fcc_hybrid\iar\apps_phy_tester_hybrid_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter\pic32cx2015mtsh128_pic32cxmtsh_db\iar\metrology_demometer_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_cen_a\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_cen_a_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_cen_b\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_cen_b_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_fcc\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_fcc_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_fcc_cen_a\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtsh_db_pl460_fcc_cen_a_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter\pic32cx2051mtc128_pic32cxmtc_db\iar\metrology_demometer_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_cen_a\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_cen_a_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_fcc\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_fcc_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_fcc_cen_a\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\..\metrology\demo_meter_g3\pic32cxmtc_db_pl460_fcc_cen_a_hybrid\iar\thirdparty_metrology_demometer_g3_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms16c_atpl360mb_cen_a_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms16c_atpl360mb_cen_b_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\adp_mac_serialized_app\sam4cms16c_atpl360mb_fcc_rt\iar\apps_adp_mac_serialized_app_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\sam4cms16c_atpl360mb_cen_a_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\sam4cms16c_atpl360mb_cen_b_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\sam4cms16c_atpl360mb_fcc_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_coord\sam4cms16c_atpl360mb_multiband_rt\iar\apps_dlms_app_coord_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms16c_atpl360mb_cen_a_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms16c_atpl360mb_cen_b_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms16c_atpl360mb_fcc_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_dev\sam4cms16c_atpl360mb_multiband_rt\iar\apps_dlms_app_dev_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_meter\sam4cms16c_atpl360mb\iar\apps_dlms_app_meter_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_modem\sam4cms16c_atpl360mb_cen_a_rt\iar\apps_dlms_app_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_modem\sam4cms16c_atpl360mb_cen_b_rt\iar\apps_dlms_app_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\dlms_app_modem\sam4cms16c_atpl360mb_fcc_rt\iar\apps_dlms_app_modem_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms16c_atpl360mb_cen_a\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms16c_atpl360mb_cen_b\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\mac_rt_plc_and_go_plus\sam4cms16c_atpl360mb_fcc\iar\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms16c_atpl360mb_cen_a\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms16c_atpl360mb_cen_b\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_plc_and_go\sam4cms16c_atpl360mb_fcc\iar\apps_phy_plc_and_go_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\sam4cms16c_atpl360mb_cen_a\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\sam4cms16c_atpl360mb_cen_b\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_sniffer_tool\sam4cms16c_atpl360mb_fcc\iar\apps_phy_sniffer_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms16c_atpl360mb_cen_a\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms16c_atpl360mb_cen_b\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tester_tool\sam4cms16c_atpl360mb_fcc\iar\apps_phy_tester_tool_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms16c_atpl360mb_cen_a\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms16c_atpl360mb_cen_b\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<project>
		<path>$WS_DIR$\..\..\..\phy\atpl360\apps\phy_tx_test_console\sam4cms16c_atpl360mb_fcc\iar\apps_phy_tx_test_console_flash.ewp</path>
	</project>
	<batchBuild>
		<batchDefinition>
			<name>All</name>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_meter_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_meter_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>serial_bootloader_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_hybrid_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>metrology_demometer_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>metrology_demometer_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>thirdparty_metrology_demometer_g3_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_adp_mac_serialized_app_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_coord_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_dev_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_meter_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_dlms_app_modem_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_mac_rt_plc_and_go_plus_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_plc_and_go_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_sniffer_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tester_tool_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
			<member>
				<project>apps_phy_tx_test_console_flash</project>
				<configuration>Debug</configuration>
			</member>
		</batchDefinition>
	</batchBuild>
</workspace>