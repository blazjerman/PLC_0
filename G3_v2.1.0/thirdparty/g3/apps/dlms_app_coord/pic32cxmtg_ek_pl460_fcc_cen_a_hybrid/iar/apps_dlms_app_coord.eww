<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_dlms_app_coord_flash.ewp</path>
	</project>
</workspace>
