# Keil uVision project apps_dlms_app_coord_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: IROM(0x00400000,0x00200000) IRAM(0x20400000,0x00060000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: apps_template_app
  c flags: Optim=3 oTime=1 OneElfS=1 uC99=1 wLevel=2
  c define: __G3_STACK__ UDD_ENABLE ARM_MATH_CM7=true BOARD=SAME70_XPLAINED __RF_MAC__ __FREERTOS__ __SAME70Q21B__ __PLC_MAC__
  c misc: --diag_suppress=66 --gnu
  c include: ..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\common\services\usb\class\cdc\device;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\common\services\usb;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\..\sam\utils\cmsis\same70\include;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\usbhs;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\sam\drivers\pio;..\..\..\..\pal_rf\rf215_g3mac\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\dlms\client\lib;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\services\plc\usb_wrp;..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates;..\..\..\..\coordinator\source;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\drivers\xdmac;..\..\..\..\..\cycloneTCP\common;..\..\..\..\..\..\common\utils\stdio\stdio_udc;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\coordinator\include;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\common\source;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\..\..\sam\drivers\mpu;..\..\..\..\oss;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\adp\include;..\..\..\..\mac\include;..\..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\sam\drivers\pmc;..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\common\services\gpio;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\sam\drivers\matrix;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\drivers\wdt;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\mac_common\include;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\common\boards;..\..\..\..\..\dlms\client\profile_g3;..\..\..\..\..\..\common\services\usb\udc;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\..\..\sam\drivers\afec;..\..\..\..\..\..\sam\boards\same70_xplained;..\..\..\..\routing_loadng\include;..;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\usb\class\cdc;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\sam\drivers\supc;..\..\..\..\..\..\common\services\clock;..\..\..\..\mac_rf\include;..\..\..\..\common\include;..\..\..\..\..\..\common\services\serial\sam_uart;..\..;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: sram.sct
  link misc: --diag_suppress=L6314
target flash (ARM-ADS)
  device: ATSAME70Q21 Atmel
  pack: Keil.SAM-E_DFP.2.1.0
  cpu: as above
  output: uart
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BOARD_SAME70_XPLD __SAME70Q21__ flash TRACE_LEVEL=4
  c include: ..\..\;..\..\..\..\libraries\libchip;..\..\..\..\libraries\libchip\include;..\..\..\..\libraries\libchip\include\same70;..\..\..\..\libraries\libchip\include\cmsis\CMSIS\Include;..\..\..\..\libraries\libboard;..\..\..\..\libraries\libboard\include
  memory RVCT4: ROM 0x400000 size 0x200000
  memory RVCT9: RAM 0x20400000 size 0x60000
  scatter file: flash.sct
  link misc: --diag_suppress=L6314
  group added to the first target's files
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360.c atpl360_boot.c atpl360_hal_spi.c
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
    ../../../../../../common/services/clock/same70/: sysclk.c
    ../../../../../../common/services/delay/sam/: cycle_counter.c
    ../../../../../../common/services/serial/: usart_serial.c
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
    ../../../../../../common/services/usb/class/cdc/device/: udi_cdc.c udi_cdc_desc.c
    ../../../../../../common/services/usb/udc/: udc.c
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
    ../../../../../../common/utils/stdio/: read.c write.c
    ../../../../../../sam/boards/same70_xplained/: init.c
    ../../../../../../sam/drivers/aes/: aes.c
    ../../../../../../sam/drivers/afec/: afec.c
    ../../../../../../sam/drivers/efc/: efc.c
    ../../../../../../sam/drivers/gpbr/: gpbr.c
    ../../../../../../sam/drivers/matrix/: matrix.c
    ../../../../../../sam/drivers/mpu/: mpu.c
    ../../../../../../sam/drivers/pio/: pio.c pio_handler.c
    ../../../../../../sam/drivers/pmc/: pmc.c sleep.c
    ../../../../../../sam/drivers/rstc/: rstc.c
    ../../../../../../sam/drivers/spi/: spi.c
    ../../../../../../sam/drivers/supc/: supc.c
    ../../../../../../sam/drivers/tc/: tc.c
    ../../../../../../sam/drivers/trng/: trng.c
    ../../../../../../sam/drivers/uart/: uart.c
    ../../../../../../sam/drivers/usart/: usart.c
    ../../../../../../sam/drivers/usbhs/: usbhs_device.c
    ../../../../../../sam/drivers/wdt/: wdt.c
    ../../../../../../sam/drivers/xdmac/: xdmac.c
    ../../../../../../sam/services/flash_efc/: flash_efc.c
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
    ../../../../../../sam/services/plc/usb_wrp/: usb_wrp.c
    ../../../../../../sam/services/plc/usi/: usi.c
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
    ../../../../../../sam/services/timer_1us/hal_same70/: timer_1us_hal.c
    ../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
    ../../../../../cycloneTCP/common/: cpu_endian.c date_time.c debug.c os_port_none.c path.c str.c
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: asn1.c oid.c
    ../../../../../cycloneTCP/cyclone_tcp/core/: ethernet.c ethernet_misc.c ip.c net.c net_mem.c nic.c ping.c raw_socket.c socket.c tcp.c tcp_fsm.c tcp_misc.c tcp_timer.c udp.c
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_client.c dns_common.c dns_debug.c
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/mac/: same70_eth_driver.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/phy/: ksz8081_driver.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: icmpv6.c ipv6.c ipv6_frag.c ipv6_misc.c ipv6_pmtu.c ipv6_routing.c mld.c ndp.c ndp_cache.c ndp_misc.c ndp_router_adv.c slaac.c
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_client.c mdns_common.c mdns_responder.c
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: ip_mib_impl.c ip_mib_module.c mib2_impl.c mib2_module.c mib_common.c tcp_mib_impl.c tcp_mib_module.c udp_mib_impl.c udp_mib_module.c
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: chap.c ipcp.c ipv6cp.c lcp.c pap.c ppp.c ppp_debug.c ppp_fsm.c ppp_hdlc.c ppp_misc.c
    ../../../../../dlms/client/profile_g3/: dlms_cli_data_example.c
    ../../../../../dlms/libs/keil/: libsamM4-dlms-client-keil.lib
    ../../../../../mbed-tls/library/: aes_tls.c aesni.c ccm.c cipher.c cipher_wrap.c cmac.c debug_tls.c error.c gcm.c memory_buffer_alloc.c oid_tls.c platform.c platform_util.c timing.c version.c version_features.c
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
    ../../../../adp/: AdpConf.c
    ../../../../bootstrap_lbp/source/: ProcessLbpCoord.c ProtoEapPsk.c ProtoLbp.c
    ../../../../common/source/: Logger.c QueueMng.c Random.c Timer.c
    ../../../../coordinator/source/: bs_functions.c bs_main.c
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
    ../../../../hal/SAM_atpl360/: hal.c
    ../../../../libs/keil/: lib-g3-keil-adp.lib lib-g3-keil-loadng.lib lib-g3-keil-mac-rf.lib lib-g3-keil-mac.lib
    ../../../../mac_common/source/: MacCommon.c
    ../../../../mac_wrapper/source/: mac_wrapper.c
    ../../../../oss/: oss_if.c
    ../../../../pal/atpl360_g3macrt/source/: pal.c
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
    ../../../../routing_wrapper/source/: RoutingWrapper.c
    ../../../../storage/: storage.c
    ../../: app_adp_mng.c app_dispatcher.c app_dlms_coord.c app_ping_coord.c app_udp_responder.c dlms_cli_data.c ipv6_mng.c main.c
    ./: atpl_bin_multi.S retarget.c startup_SAME70.s system_same70.c
software components: CMSIS:CORE 4.3.0, CMSIS:DSP 1.4.6
