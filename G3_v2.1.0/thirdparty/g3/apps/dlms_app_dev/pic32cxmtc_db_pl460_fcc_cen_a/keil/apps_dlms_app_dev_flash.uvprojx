# Keil uVision project apps_dlms_app_dev_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTC128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20080000,0x00008000) IRAM3(0x20088000,0x00004000) IROM(0x01000000,0x00100000) IROM2(0x01100000,0x00100000) IROM3(0x11000000,0x00100000) IROM4(0x11100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_dlms_app_dev_flash
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __G3_STACK__ BOARD=PIC32CXMTC_DB __PIC32CX2051MTC128__ __FREERTOS__ ARM_MATH_CM4=true __PLC_MAC__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\routing_wrapper\source;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\adp\include;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..;..\..\..;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\..\..\sam\utils;..\..\..\..\..\..\sam\boards\pic32cxmtc_db;..\..\..\..\routing_loadng\source;..\..\..\..\routing_wrapper\include;..\..\..\..\bootstrap_lbp\include;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\boards;..\..\..\..\mac\include;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\routing_loadng\include;..\..\..\..\mac_common\include;..\..\..\..\..\..\common\utils;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\dlms\server\lib;..\..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\mbed-tls\library;..\..\..\..\..\..\sam\drivers\sfr;..\..\..\..\common\source;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\..\dlms\server\profile_g3;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\common\include;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\..\..\sam\components\display\cl010;..\..\..\..\oss;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\mac_wrapper\include;..\..\..\..\..\cycloneTCP\common;..\..\..\..\phy\atpl360\coup_tx_config;..\..;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8c000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbpDev.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_apps_dlms_app_dev
    ../../: app_dispatcher.c dlms_dev.c main.c app_udp_responder.c ipv6_mng.c app_ping_dev.c dlms_srv_data.c app_adp_mng.c
  group thirdparty_g3_crypto
    ../../../../crypto/: aes_wrapper.c cipher_wrapper.c eax.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_mac_common_source
    ../../../../mac_common/source/: MacCommon.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3
    ../../../../../dlms/server/profile_g3/: dlms_srv_data_example.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp_timer.c tcp.c ethernet_misc.c udp.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net_mem.c net.c socket.c ping.c tcp_fsm.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: ndp.c mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp_router_adv.c slaac.c ndp_cache.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c
  group thirdparty_cycloneTCP_common
    ../../../../../cycloneTCP/common/: date_time.c debug.c cpu_endian.c os_port_none.c str.c path.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
  group thirdparty_mbed-tls_library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c cipher.c aesni.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group thirdparty_mbed-tls_sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pmc_pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_pio_pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_sfr
    ../../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_supc_pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_aes
    ../../../../../../sam/drivers/aes/: aes.c
  group sam_components_display_cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c
  group sam_boards_pic32cxmtc_db
    ../../../../../../sam/boards/pic32cxmtc_db/: init.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
