# Keil uVision project apps_dlms_app_dev_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTC128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20080000,0x00008000) IRAM3(0x20088000,0x00004000) IROM(0x01000000,0x00100000) IROM2(0x01100000,0x00100000) IROM3(0x11000000,0x00100000) IROM4(0x11100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_dlms_app_dev_flash
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __G3_STACK__ BOARD=PIC32CXMTC_DB __RF_MAC__ __PIC32CX2051MTC128__ __FREERTOS__ ARM_MATH_CM4=true __PLC_MAC__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\routing_wrapper\source;..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\freertos\freertos-7.3.0\source\include;..\..\..\..\phy\atpl360\coup_tx_config;..\..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\..\common\utils;..\..\..\..\pal\atpl360_g3macrt\include;..\..\..\..\pal_rf\rf215_g3mac\include;..\..\..\..\..\..\sam\components\display\cl010;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\mbed-tls\include;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\sam\services\flash_efc;..\..\..\..\..\cycloneTCP\common;..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\..\..\sam\boards\pic32cxmtc_db;..\..\..\..\..\..\sam\utils;..\..\..\..\routing_loadng\source;..\..\..\..\mac_rt\include;..\..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\mac_rf\include;..\..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\..\oss;..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\..\sam\utils\header_files;..\..\..\..;..\..\..\..\..\cycloneTCP\module_config;..\..\..\..\..\..\sam\drivers\sfr;..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\adp\include;..\..\..;..\..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\..\freertos\freertos-7.3.0\source\portable\iar\sam_cm4f;..\..\..\..\routing_wrapper\include;..\..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\mac\include;..\..\..\..\..\dlms\server\profile_g3;..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\cycloneTCP\atpl_extension;..;..\..\..\..\bootstrap_lbp\include;..\..\..\..\..\..\common\services\sleepmgr;..\..;..\..\..\..\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\mac_common\include;..\..\..\..\..\..\common\boards;..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\..\..\..\sam\drivers\adc;..\..\..\..\routing_loadng\include;..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\common\services\delay;..\..\..\..\..\dlms\server\lib;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\bootstrap_lbp\source;..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\mbed-tls\library;..\..\..\..\common\source;..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\common\include;..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\mac_wrapper\include;..\..\..\..\..\..\sam\drivers\usart;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8c000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c atpl_bin_multi.S
  group thirdparty_g3_libs_keil
    ../../../../libs/keil/: lib-g3-keil-loadng.lib lib-g3-keil-mac.lib lib-g3-keil-adp.lib lib-g3-keil-mac-rf.lib
  group thirdparty_g3_pal_rf_rf215_g3mac_source
    ../../../../pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../bootstrap_lbp/source/: ProcessLbpDev.c ProtoEapPsk.c ProtoLbp.c
  group thirdparty_g3_crypto
    ../../../../crypto/: eax.c aes_wrapper.c cipher_wrapper.c
  group thirdparty_g3_apps_dlms_app_dev
    ../../: app_dispatcher.c dlms_dev.c main.c app_udp_responder.c ipv6_mng.c app_ping_dev.c dlms_srv_data.c app_adp_mng.c
  group thirdparty_g3_common_source
    ../../../../common/source/: Logger.c Timer.c Random.c QueueMng.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../hal/SAM_atpl360/: hal.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_oss
    ../../../../oss/: oss_if.c
  group thirdparty_g3_adp
    ../../../../adp/: AdpConf.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_mac_common_source
    ../../../../mac_common/source/: MacCommon.c
  group thirdparty_g3_storage
    ../../../../storage/: storage.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../mac_wrapper/source/: mac_wrapper.c
  group thirdparty_dlms_libs_keil
    ../../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3
    ../../../../../dlms/server/profile_g3/: dlms_srv_data_example.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../../cycloneTCP/cyclone_crypto/encoding/: oid.c asn1.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../../cycloneTCP/cyclone_tcp/core/: tcp.c tcp_timer.c ethernet_misc.c net_mem.c ip.c tcp_misc.c nic.c ethernet.c raw_socket.c net.c socket.c ping.c tcp_fsm.c udp.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../../cycloneTCP/cyclone_tcp/mibs/: mib2_module.c udp_mib_module.c udp_mib_impl.c tcp_mib_impl.c tcp_mib_module.c ip_mib_impl.c mib_common.c mib2_impl.c ip_mib_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_debug.c dns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../../cycloneTCP/cyclone_tcp/ipv6/: ndp.c mld.c ipv6_frag.c ipv6_routing.c ipv6_misc.c ipv6.c ndp_misc.c ipv6_pmtu.c icmpv6.c ndp_router_adv.c slaac.c ndp_cache.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../../cycloneTCP/cyclone_tcp/ppp/: pap.c ppp_fsm.c lcp.c chap.c ipv6cp.c ppp_debug.c ppp_hdlc.c ppp_misc.c ppp.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_common
    ../../../../../cycloneTCP/common/: date_time.c debug.c cpu_endian.c os_port_none.c str.c path.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../../cycloneTCP/atpl_extension/: async_ping.c
  group thirdparty_mbed-tls_library
    ../../../../../mbed-tls/library/: memory_buffer_alloc.c cipher.c aesni.c error.c ccm.c cipher_wrap.c debug_tls.c platform.c version.c aes_tls.c cmac.c timing.c oid_tls.c version_features.c gcm.c platform_util.c
  group thirdparty_mbed-tls_sam_aes_alt
    ../../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group sam_services_plc_buart_if
    ../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_timer_1us
    ../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_services_flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_drivers_pmc_pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c
  group sam_drivers_pdc
    ../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_tc
    ../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_rstc
    ../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_uart
    ../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_trng
    ../../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_adc
    ../../../../../../sam/drivers/adc/: adc.c
  group sam_drivers_efc
    ../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_pio_pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_sfr
    ../../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_usart
    ../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_supc_pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_spi
    ../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_aes
    ../../../../../../sam/drivers/aes/: aes.c
  group sam_components_display_cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c
  group sam_boards_pic32cxmtc_db
    ../../../../../../sam/boards/pic32cxmtc_db/: init.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_bbc
    ../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_rf_at86rf215
    ../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_addons_sniffer_if_g3
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
  group common_components_rf_at86rf215_addons_sniffer_if
    ../../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common_components_plc_atpl360_g3_mac_rt_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360_hal_spi.c atpl360.c
  group common_utils_stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group common_services_delay_sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_sleepmgr_sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_serial
    ../../../../../../common/services/serial/: usart_serial.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
