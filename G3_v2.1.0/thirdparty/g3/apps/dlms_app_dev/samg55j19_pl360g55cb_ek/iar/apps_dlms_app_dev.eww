<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_dlms_app_dev_flash.ewp</path>
	</project>
</workspace>
