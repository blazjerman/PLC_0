<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_dlms_app_modem_flash.ewp</path>
	</project>
</workspace>
