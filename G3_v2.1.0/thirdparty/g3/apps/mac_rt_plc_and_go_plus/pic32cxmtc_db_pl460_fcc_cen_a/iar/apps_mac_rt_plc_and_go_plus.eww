<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_mac_rt_plc_and_go_plus_flash.ewp</path>
	</project>
</workspace>
