# IAR project apps_mac_rt_plc_and_go_plus_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTC128 Microchip PIC32CX2051MTC128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PIC32CX2051MTC128__; BOARD=PIC32CXMTC_DB; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..; ..\..\..\..\..\..\sam\utils; ..\..\..\..\phy\atpl360\coup_tx_config; ..\..\..\..\..\..\common\boards; ..\..\..\..\mac_rt\include; ..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\sam\drivers\rstc; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_mac_rt_plc_and_go_plus_flash.bin
  ILINK.IlinkOutputFile: apps_mac_rt_plc_and_go_plus_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group sam/drivers/trng
    ../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/sfr
    ../../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/usart
    ../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/tc
    ../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/rstc
    ../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/uart
    ../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/efc
    ../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/slcdc
    ../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/spi
    ../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/pio/pic32cx
    ../../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/flexcom
    ../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/adc
    ../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/components/display/cl010
    ../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010_segmap.h cl010.h
  group sam/utils
    ../../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cxmt.h pic32cx2051mtsh128S1.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx5112mtsh128.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx5112mtc128S1.h pic32cx2051mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx1025mtg64.h pic32cx1025mtsh128S1.h pic32cx2051mtc128.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h system_pic32cxmt.h pic32cx5112mtc128.h pic32cx1025mtc128S1.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../sam/utils/cmsis/pic32cx/include/instance/: flexcom4.h spi7.h twi0.h usart3.h pmc.h flexcom2.h cmcc0.h ipc1.h matrix2.h twi7.h usart7.h cmcc1.h flexcom0.h spi5.h twi2.h flexcom6.h twi4.h mem2mem0.h spi4.h rstc.h trng.h ipc0.h usart0.h usart2.h usart6.h sha.h emafe.h sfr.h aes.h rtt.h sfrbu.h twi6.h spi3.h gpbr.h matrix0.h spi1.h cpkcc.h pio.h rtc.h tc2.h usart1.h slcdc.h tc0.h acc.h qspi.h sefc1.h adc.h flexcom5.h spi2.h matrix3.h syscwp.h twi1.h mcspi.h matrix1.h spi0.h twi5.h uart.h supc.h usart5.h tc3.h flexcom1.h tc1.h aesb.h flexcom3.h pwm.h icm.h usart4.h sefc0.h chipid.h spi6.h twi3.h flexcom7.h dwdt.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../sam/utils/cmsis/pic32cx/include/component/: flexcom.h sfr.h rtt.h mem2mem.h mcspi.h emafe.h supc.h cpkcc.h qspi.h rstc.h twi.h slcdc.h ipc.h pdc.h acc.h uart.h trng.h tc.h aes.h dwdt.h icm.h pio.h cmcc.h spi.h adc.h chipid.h gpbr.h pwm.h rtc.h sha.h pmc.h aesb.h syscwp.h matrix.h sefc.h usart.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx5112mtc128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtc128.h pic32cx2051mtg64.h pic32cx5112mtsh128.h
  group sam/utils/header_files
    ../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../sam/utils/preprocessor/: preprocessor.h mrepeat.h stringz.h tpaste.h
  group sam/boards/pic32cxmtc_db
    ../../../../../../sam/boards/pic32cxmtc_db/: init.c pic32cxmtc_db.h led.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus
    ../../: mac_rt_plc_and_go_plus.c app_plc.c app_console.c app_plc.h app_console.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/pic32cxmtc_db_pl460_fcc_cen_a
    ../: conf_cl010_slcdc.h conf_clock.h conf_slcdc.h conf_sleepmgr.h conf_pplc_if.h conf_uart_serial.h conf_board.h conf_project.h conf_atpl360.h
  group thirdparty/g3/apps/mac_rt_plc_and_go_plus/pic32cxmtc_db_pl460_fcc_cen_a/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../phy/atpl360/coup_tx_config/coup_params/: plcoup007_cen_a.h pl460_1_5b_fcc.h pl460_sb_fcc.h pl460_plcoup007_cen_a.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/mac_rt/include
    ../../../../mac_rt/include/: MacRtDefs.h MacRtConstants.h MacRtMib.h MacRt.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360.c atpl360_hal_spi.c atpl360_boot.c atpl360_exception.h atpl360_boot.h atpl360.h atpl360_hal_spi.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/services/sleepmgr
    ../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/serial
    ../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/clock
    ../../../../../../common/services/clock/: pll.h sysclk.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h pll.h sysclk.h
  group common/services/delay
    ../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/utils
    ../../../../../../common/utils/: parts.h interrupt.h
  group common/utils/stdio
    ../../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../common/boards/: board.h
