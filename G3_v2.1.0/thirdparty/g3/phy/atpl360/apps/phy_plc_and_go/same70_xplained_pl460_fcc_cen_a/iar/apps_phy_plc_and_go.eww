<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_phy_plc_and_go_flash.ewp</path>
	</project>
</workspace>
