<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\apps_phy_sniffer_hybrid_tool_flash.ewp</path>
	</project>
</workspace>
