# IAR project apps_phy_tester_hybrid_tool_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTC128 Microchip PIC32CX2051MTC128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __PIC32CX2051MTC128__; BOARD=PIC32CXMTC_DB; ARM_MATH_CM4=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\coup_tx_config; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons; ..\..\..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tester_hybrid_tool_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tester_hybrid_tool_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../../../../common/services/clock/pic32cx/: sysclk.c osc.h pll.h sysclk.h genclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/components/rf/at86rf215
    ../../../../../../../../common/components/rf/at86rf215/: at86rf215.c ieee_15_4_sun_fsk.h at86rf.h ieee_15_4_sun_ofdm.h at86rf_defs.h at86rf_version.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_trx_ctl.c rf215_spi.c rf215_spi.h rf215_trx_ctl.h rf215_phy_defs.h rf215_reg.h rf215_conf_check.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq.h rf215_irq_defs.h
  group common/components/rf/at86rf215/addons
    ../../../../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/serial_if
    ../../../../../../../../common/components/rf/at86rf215/addons/serial_if/: rf215_serial_if.c
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c rf215_tx_rx_defs.h rf215_tx_rx.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll_defs.h rf215_pll.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe.h rf215_fe_defs.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/addons
    ../../../../../../../../common/components/plc/atpl360/addons/: addon_api.h
  group common/components/plc/atpl360/addons/serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c serial_if.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group sam/boards/pic32cxmtc_db
    ../../../../../../../../sam/boards/pic32cxmtc_db/: init.c led.h pic32cxmtc_db.h
  group sam/services/plc/busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/plc/usi
    ../../../../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c timer_1us.h timer_1us_hal.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/drivers/pio/pic32cx
    ../../../../../../../../sam/drivers/pio/pic32cx/: pio.c pio_handler.c pio.h pio_handler.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/sfr
    ../../../../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/slcdc
    ../../../../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/supc/pic32cx
    ../../../../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/pmc/pic32cx
    ../../../../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c sleep.h pmc.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/components/display/cl010
    ../../../../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010_font.h cl010.h cl010_segmap.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/: pic32cx5112mtg128.h pic32cx2051mtsh128S1.h pic32cx1025mtsh128.h pic32cx2051mtsh128.h pic32cx2051mtg64.h pic32cx1025mtg128.h pic32cx2051mtc128S1.h pic32cx5112mtc128S1.h pic32cx5112mtsh128.h pic32cx1025mtsh128S1.h pic32cx1025mtg64.h pic32cx2051mtc128.h pic32cx1025mtc128S1.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h pic32cx5112mtc128.h pic32cxmt.h system_pic32cxmt.h pic32cx2051mtg128.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/instance/: twi0.h flexcom4.h flexcom3.h spi7.h ipc1.h cmcc0.h pmc.h twi1.h flexcom2.h twi6.h dwdt.h usart6.h usart7.h adc.h flexcom0.h twi4.h rstc.h twi2.h flexcom6.h spi5.h spi4.h ipc0.h trng.h mcspi.h sha.h usart2.h sfr.h spi1.h usart0.h sefc0.h mem2mem0.h sfrbu.h aes.h matrix0.h spi0.h icm.h tc0.h spi3.h aesb.h tc2.h pio.h rtc.h slcdc.h cpkcc.h gpbr.h acc.h usart3.h usart1.h matrix2.h sefc1.h qspi.h spi2.h emafe.h matrix3.h cmcc1.h flexcom5.h matrix1.h syscwp.h tc1.h twi7.h tc3.h usart5.h supc.h twi5.h uart.h flexcom1.h rtt.h pwm.h usart4.h chipid.h flexcom7.h twi3.h spi6.h mem2mem1.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/component/: mcspi.h rtt.h sfr.h emafe.h supc.h aesb.h tc.h acc.h ipc.h rstc.h cpkcc.h sha.h pmc.h matrix.h trng.h uart.h rtc.h dwdt.h aes.h icm.h adc.h spi.h cmcc.h pio.h pdc.h mem2mem.h sefc.h usart.h twi.h chipid.h pwm.h qspi.h flexcom.h syscwp.h gpbr.h slcdc.h sfrbu.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx1025mtg64.h pic32cx1025mtc128.h pic32cx2051mtg128.h pic32cx2051mtsh128.h pic32cx5112mtg128.h pic32cx1025mtsh128.h pic32cx5112mtc128.h pic32cx1025mtg128.h pic32cx5112mtsh128.h pic32cx2051mtc128.h pic32cx2051mtg64.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: tpaste.h mrepeat.h stringz.h preprocessor.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: pl460_sb_fcc.h pl460_1_5b_fcc.h pl460_plcoup007_cen_a.h plcoup007_cen_a.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool
    ../../: phy_embedded_example.c
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool/pic32cxmtc_db_pl460_fcc_cen_a_hybrid
    ../: conf_at86rf.h conf_cl010_slcdc.h conf_timer_1us.h conf_project.h conf_clock.h conf_prf_if.h conf_buart_if.h conf_slcdc.h conf_usi.h conf_sleepmgr.h conf_pplc_if.h conf_board.h conf_busart_if.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl360/apps/phy_tester_hybrid_tool/pic32cxmtc_db_pl460_fcc_cen_a_hybrid/iar
    ./: asf.h
