# Keil uVision project apps_phy_tester_hybrid_tool_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTC128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20080000,0x00008000) IRAM3(0x20088000,0x00004000) IROM(0x01000000,0x00100000) IROM2(0x01100000,0x00100000) IROM3(0x11000000,0x00100000) IROM4(0x11100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: apps_phy_tester_hybrid_tool_flash
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __PIC32CX2051MTC128__ BOARD=PIC32CXMTC_DB ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\..\..\..\sam\drivers\spi;..\..\..\..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons\serial_if;..\..\..\..\..\..\..\..\common\services\ioport;..\..\..\..\..\..\..\..\sam\boards\pic32cxmtc_db;..\..\..\..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\..\..\..\..\sam\utils;..\..\..\..\coup_tx_config;..\..\..\..\coup_tx_config\coup_params;..\..\..\..\..\..\..\..\sam\drivers\tc;..\..\..\..\..\..\..\..\common\components\plc\atpl360;..\..\..\..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\..\..\..\sam\boards;..\..\..\..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\addons;..\..;..\..\..\..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\..\..\..\common\utils;..\..\..\..\..\..\..\..\common\services\delay;..\..\..\..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\..\..\..\common\boards;..\..\..\..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\..\..\..\..\sam\components\display\cl010;..\..\..\..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\..\..\..\sam\drivers\adc;..;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\..\..\..\..\sam\services\plc\busart_if;..\..\..\..\..\..\..\..\common\services\clock;..\..\..\..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3;..\..\..\..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_a;..\..\..\..\..\..\..\..\sam\utils\header_files;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\..\..\..\..\sam\drivers\sfr;..\..\..\..\..\..\..\..\common\services\serial;..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\..\..\..\common\components\plc\atpl360\addons;..\..\..\..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\coup_tx_config\pl360_wrp\g3_phy;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8c000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c atpl_bin_multi.S
  group common_services_sleepmgr_sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_clock_pic32cx
    ../../../../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_serial
    ../../../../../../../../common/services/serial/: usart_serial.c
  group common_services_delay_sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c
  group common_components_rf_at86rf215
    ../../../../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../../../../common/components/rf/at86rf215/rf215_common/: rf215_trx_ctl.c rf215_spi.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_addons_serial_if
    ../../../../../../../../common/components/rf/at86rf215/addons/serial_if/: rf215_serial_if.c
  group common_components_rf_at86rf215_rf215_bbc
    ../../../../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_rx.c rf215_tx.c
  group common_components_rf_at86rf215_rf215_pll
    ../../../../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_plc_atpl360_addons_serial_if
    ../../../../../../../../common/components/plc/atpl360/addons/serial_if/: serial_if.c serial_if_g3.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_boot.c atpl360.c
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c
  group common_components_plc_atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360_IB.c atpl360_hal_spi.c
  group common_utils_stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common_utils_interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam_boards_pic32cxmtc_db
    ../../../../../../../../sam/boards/pic32cxmtc_db/: init.c
  group sam_services_plc_busart_if
    ../../../../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_buart_if
    ../../../../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_pcrc
    ../../../../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_plc_usi
    ../../../../../../../../sam/services/plc/usi/: usi.c
  group sam_services_timer_1us
    ../../../../../../../../sam/services/timer_1us/: timer_1us.c
    ../../../../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_drivers_pio_pic32cx
    ../../../../../../../../sam/drivers/pio/pic32cx/: pio.c pio_handler.c
  group sam_drivers_pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_sfr
    ../../../../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_uart
    ../../../../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_spi
    ../../../../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_tc
    ../../../../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_slcdc
    ../../../../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_efc
    ../../../../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_supc_pic32cx
    ../../../../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_flexcom
    ../../../../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_pmc_pic32cx
    ../../../../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c
  group sam_drivers_usart
    ../../../../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_adc
    ../../../../../../../../sam/drivers/adc/: adc.c
  group sam_components_display_cl010
    ../../../../../../../../sam/components/display/cl010/: cl010_slcdc.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c
  group thirdparty_g3_phy_atpl360_apps_phy_tester_hybrid_tool
    ../../: phy_embedded_example.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
