# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAM4CMS16C_0 Atmel ATSAM4CMS16C Core0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..; ..\..\..\..\..\..\..\..\sam\drivers\adc; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\source\templates; ..\..\..\..\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\utils\cmsis\sam4cm\include; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\sam\boards\sam4cms_db; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: __SAM4CMS16C_0__; ARM_MATH_CM4=true; BOARD=SAM4CMS_DB
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\sam4cm\iar\sam4cms16c_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/pdc
    ../../../../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c sleep.h pmc.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/adc
    ../../../../../../../../sam/drivers/adc/: adc.c adc_sam3u.c adc.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/sam4cm/source/templates
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/: system_sam4cm.c
  group sam/utils/cmsis/sam4cm/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/sam4cm/source/templates/iar/: startup_sam4cm.c
  group sam/utils/cmsis/sam4cm/include
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/: sam4cmp16c_0.h sam4cms8c_1.h sam4cms4c_1.h system_sam4cm.h sam4cms8c_0.h sam4cms4c_0.h sam4cms16c_1.h sam4cmp8c_0.h sam4cms16c_0.h sam4cm.h sam4cmp16c_1.h sam4cmp8c_1.h
  group sam/utils/cmsis/sam4cm/include/instance
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/instance/: aes.h rstc.h tc1.h usart0.h cmcc0.h twi1.h slcdc.h piob.h rtc.h matrix1.h uart0.h adc.h usart2.h cmcc1.h trng.h rswdt.h pioc.h tc0.h pwm.h pioa.h spi0.h matrix0.h ipc0.h chipid.h ipc1.h icm.h usart3.h smc1.h supc.h spi1.h twi0.h efc.h smc0.h uart1.h usart1.h rtt.h gpbr.h wdt.h pmc.h
  group sam/utils/cmsis/sam4cm/include/pio
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/pio/: sam4cmp16c.h sam4cms8c.h sam4cms16c.h sam4cmp8c.h sam4cms4c.h
  group sam/utils/cmsis/sam4cm/include/component
    ../../../../../../../../sam/utils/cmsis/sam4cm/include/component/: wdt.h pio.h rswdt.h rtt.h rstc.h aes.h trng.h usart.h pdc.h matrix.h rtc.h chipid.h adc.h efc.h ipc.h tc.h cmcc.h gpbr.h pwm.h pmc.h supc.h spi.h slcdc.h icm.h uart.h twi.h smc.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/sam4cms_db
    ../../../../../../../../sam/boards/sam4cms_db/: init.c led.h sam4cms_db.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_IB.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/sam4cm
    ../../../../../../../../common/services/clock/sam4cm/: sysclk.c genclk.h pll.h sysclk.h osc.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_example.c phy_tx_test_console.c phy_embedded_example.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/sam4cms_db_pl460_fcc_cen_a
    ../: conf_project.h conf_clock.h conf_pplc_if.h conf_board.h conf_atpl360.h conf_uart_serial.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/sam4cms_db_pl460_fcc_cen_a/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: pl460_sb_fcc.h plcoup007_cen_a.h pl460_1_5b_fcc.h pl460_plcoup007_cen_a.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
