# IAR project apps_phy_tx_test_console_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: ATSAME70Q21xB Microchip ATSAME70Q21xB
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  ICCARM.CCDefines: BOARD=PL360BN; __SAME70Q21B__; ARM_MATH_CM7=true
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\..\..\sam\drivers\spi; ..\..\..\..\coup_tx_config\coup_params; ..\..\..\..\..\..\..\..\sam\utils\fpu; ..\..\..\..\..\..\..\..\common\services\ioport; ..\..\..\..\..\..\..\..\sam\utils; ..\..\..\..\coup_tx_config; ..\..\..\..\..\..\..\..\common\boards; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\include; ..\..\..\..\..\..\..\..\sam\drivers\wdt; ..\..\..\..\..\..\..\..\common\components\plc\atpl360; ..\..\..\..\..\..\..\..\sam\boards; ..\..\..\..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\..\..\..\sam\drivers\afec; ..\..\..\..\..\..\..\..\sam\drivers\pmc; ..\..; ..\..\..\..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\..\..\..\sam\drivers\gpbr; ..\..\..\..\..\..\..\..\common\utils; ..\..\..\..\..\..\..\..\common\services\delay; ..\..\..\..\..\..\..\..\sam\drivers\pio; ..; ..\..\..\..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\..\..\..\sam\drivers\mpu; ..\..\..\..\..\..\..\..\sam\drivers\tc; ..\..\..\..\..\..\..\..\sam\drivers\supc; ..\..\..\..\..\..\..\..\common\services\clock; ..\..\..\..\..\..\..\..\common\components\plc\atpl360\G3; ..\..\..\..\..\..\..\..\sam\drivers\trng; ..\..\..\..\coup_tx_config\coup_conf\pl360_cen_b; ..\..\..\..\..\..\..\..\common\services\gpio; ..\..\..\..\..\..\..\..\sam\utils\header_files; ..\..\..\..\..\..\..\..\common\services\serial\sam_uart; ..\..\..\..\..\..\..\..\sam\boards\pl360bn; ..\..\..\..\..\..\..\..\common\services\serial; ..\..\..\..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\..\..\..\sam\utils\cmsis\same70\source\templates; ..\..\..\..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\..\..\..\..\sam\drivers\xdmac; ..\..\..\..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\..\..\..\sam\drivers\usart; ..\..\..\..\coup_tx_config\pl360_wrp\g3_phy; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: BOARD=PL360BN; __SAME70Q21B__; ARM_MATH_CM7=true
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: apps_phy_tx_test_console_flash.bin
  ILINK.IlinkOutputFile: apps_phy_tx_test_console_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\..\..\..\sam\utils\linker_scripts\same70\same70q21\iar\flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\..\..\..\atpl\bin\ATPL360B_G3_CENB.bin,atpl_bin,P_atpl_bin,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  group sam/drivers/supc
    ../../../../../../../../sam/drivers/supc/: supc.c supc.h
  group sam/drivers/xdmac
    ../../../../../../../../sam/drivers/xdmac/: xdmac.c xdmac.h
  group sam/drivers/wdt
    ../../../../../../../../sam/drivers/wdt/: wdt.c wdt.h
  group sam/drivers/usart
    ../../../../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/mpu
    ../../../../../../../../sam/drivers/mpu/: mpu.c mpu.h
  group sam/drivers/uart
    ../../../../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/rstc
    ../../../../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/tc
    ../../../../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/pio
    ../../../../../../../../sam/drivers/pio/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/efc
    ../../../../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/drivers/spi
    ../../../../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/trng
    ../../../../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/pmc
    ../../../../../../../../sam/drivers/pmc/: sleep.c pmc.c pmc.h sleep.h
  group sam/drivers/gpbr
    ../../../../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/afec
    ../../../../../../../../sam/drivers/afec/: afec.c afec.h
  group sam/utils
    ../../../../../../../../sam/utils/: status_codes.h compiler.h
  group sam/utils/cmsis/same70/source/templates
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/: system_same70.c system_same70.h
  group sam/utils/cmsis/same70/source/templates/iar
    ../../../../../../../../sam/utils/cmsis/same70/source/templates/iar/: startup_same70.c
  group sam/utils/cmsis/same70/include
    ../../../../../../../../sam/utils/cmsis/same70/include/: same70n20b.h same70q19b.h same70j19b.h same70n20.h same70j20.h same70n21b.h same70.h same70n21.h same70j19.h same70q19.h same70q20.h same70j21b.h same70j21.h same70n19.h same70n19b.h same70j20b.h same70q21b.h same70q20b.h same70q21.h
  group sam/utils/cmsis/same70/include/instance
    ../../../../../../../../sam/utils/cmsis/same70/include/instance/: smc.h utmi.h qspi.h gpbr.h dacc.h usart1.h sdramc.h pioc.h i2sc0.h trng.h mcan0.h uart3.h efc.h gmac.h xdmac.h pioa.h tc3.h matrix.h usart2.h isi.h usart0.h piod.h icm.h usbhs.h twihs1.h chipid.h uart1.h spi0.h pwm1.h hsmci.h tc2.h pwm0.h tc0.h twihs2.h afec1.h mcan1.h aes.h twihs0.h uart4.h rtt.h acc.h rswdt.h rtc.h ssc.h spi1.h tc1.h pioe.h supc.h uart2.h i2sc1.h piob.h pmc.h uart0.h wdt.h afec0.h rstc.h
  group sam/utils/cmsis/same70/include/component
    ../../../../../../../../sam/utils/cmsis/same70/include/component/: afec.h gmac.h utmi.h aes.h spi.h rtc.h wdt.h uart.h xdmac.h rstc.h pio.h acc.h qspi.h gpbr.h dacc.h usart.h efc.h chipid.h supc.h pmc.h sdramc.h mcan.h twihs.h matrix.h ssc.h i2sc.h usbhs.h hsmci.h rswdt.h icm.h isi.h smc.h pwm.h trng.h tc.h rtt.h
  group sam/utils/cmsis/same70/include/pio
    ../../../../../../../../sam/utils/cmsis/same70/include/pio/: same70j19.h same70q20b.h same70n20.h same70j21.h same70q21.h same70j19b.h same70n20b.h same70n21.h same70n19.h same70q20.h same70n19b.h same70q19b.h same70q19.h same70q21b.h same70n21b.h same70j20.h same70j20b.h same70j21b.h
  group sam/utils/header_files
    ../../../../../../../../sam/utils/header_files/: io.h
  group sam/utils/fpu
    ../../../../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/preprocessor
    ../../../../../../../../sam/utils/preprocessor/: stringz.h preprocessor.h mrepeat.h tpaste.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/flash_efc
    ../../../../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/boards/pl360bn
    ../../../../../../../../sam/boards/pl360bn/: init.c pl360bn.h led.h
  group common/components/plc/atpl360
    ../../../../../../../../common/components/plc/atpl360/: atpl360.c atpl360_boot.c atpl360_IB.c atpl360_hal_spi.c atpl360_boot.h atpl360_hal_spi.h atpl360.h atpl360_IB_db_api.h atpl360_exception.h atpl360_IB.h
  group common/components/plc/atpl360/G3
    ../../../../../../../../common/components/plc/atpl360/G3/: atpl360_IB_db.c atpl360_comm.c general_defs.h atpl360_comm.h atpl360_IB_db.h
  group common/utils
    ../../../../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../../../../common/utils/stdio/: read.c write.c
  group common/utils/stdio/stdio_serial
    ../../../../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/services/sleepmgr
    ../../../../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/clock
    ../../../../../../../../common/services/clock/: sysclk.h pll.h genclk.h osc.h
  group common/services/clock/same70
    ../../../../../../../../common/services/clock/same70/: sysclk.c pll.h osc.h genclk.h sysclk.h
  group common/services/serial
    ../../../../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/sam_uart
    ../../../../../../../../common/services/serial/sam_uart/: uart_serial.h
  group common/services/delay
    ../../../../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/gpio
    ../../../../../../../../common/services/gpio/: gpio.h
  group common/services/gpio/sam_gpio
    ../../../../../../../../common/services/gpio/sam_gpio/: sam_gpio.h
  group common/services/ioport
    ../../../../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/sam
    ../../../../../../../../common/services/ioport/sam/: ioport_pio.h
  group common/boards
    ../../../../../../../../common/boards/: board.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console
    ../../: phy_embedded_example.c phy_tx_test_console.c phy_embedded_example.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/same70q21_pl360bn_cen_b
    ../: conf_project.h conf_pplc_if.h conf_uart_serial.h conf_board.h conf_clock.h conf_sleepmgr.h conf_atpl360.h
  group thirdparty/g3/phy/atpl360/apps/phy_tx_test_console/same70q21_pl360bn_cen_b/iar
    ./: asf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl360_cen_b
    ../../../../coup_tx_config/coup_conf/pl360_cen_b/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_phy
    ../../../../coup_tx_config/pl360_wrp/g3_phy/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../coup_tx_config/coup_params/: plcoup014_cen_b.h plcoup012_cen_b.h
