<workspace>
	<batchBuild></batchBuild>
	<project>
		<path>$WS_DIR$\metrology_demometer_flash.ewp</path>
	</project>
</workspace>
