# Keil uVision project metrology_demometer_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTC128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20080000,0x00008000) IRAM3(0x20088000,0x00004000) IROM(0x01000000,0x00100000) IROM2(0x01100000,0x00100000) IROM3(0x11000000,0x00100000) IROM4(0x11100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: metrology_demometer_flash
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __PIC32CX2051MTC128__ BOARD=PIC32CXMTC_DB ARM_MATH_CM4=true
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\demo_app\history;..\..\..\demo_app\presskey;..\..\..\..\..\sam\utils\fpu;..\..\..\..\..\sam\drivers\icm;..\..\..\..\..\common\services\ioport;..\..\..\..\..\sam\boards\pic32cxmtc_db;..;..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\..\sam\utils;..\..\..\..\..\sam\drivers\rtt;..\..\..\..\..\common\boards;..\..\..\..\..\sam\drivers\qspi\pic32cx;..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\sam\boards;..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\sam\drivers\chipid;..\..\..\..\..\sam\drivers\rtc;..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\demo_app\metrology;..\..\..\demo_app\energy;..\..\..\demo_app\tou;..\..\..\..\..\sam\drivers\gpbr;..\..\..\..\..\common\utils;..\..\..\demo_app\event;..\..\..\..\..\sam\drivers\usart;..\..\..\..\..\sam\drivers\cmcc;..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\..\common\components\memory\qspi_flash\sst26vfxxx;..\..\..\..\..\common\services\delay;..\..\..\..\..\sam\drivers\sfr;..\..\..\..\..\sam\components\display\cl010;..\..\..\demo_app\rtcproc;..\..\..\demo_app;..\..\..\demo_app\command;..\..\..\demo_app\display;..\..\..\..\..\common\services\clock;..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\sam\drivers\ipc;..\..;..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\sam\utils\header_files;..\..\..\demo_app\demand;..\..\..\demo_app\coproc;..\..\..\..\..\common\services\serial;..\..\..\..\..\sam\drivers\matrix\pic32cx;..\..\..\demo_app\utils;..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\sam\drivers\rstc;..\..\..\demo_app\kenerl;..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\sam\drivers\dwdt;..\..\..\demo_app\basetimer;..\..\..\demo_app\extmem;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8c000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c core1_metlib.S
  group sam_drivers_supc_pic32cx
    ../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_sfr
    ../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_cmcc
    ../../../../../sam/drivers/cmcc/: cmcc.c
  group sam_drivers_chipid
    ../../../../../sam/drivers/chipid/: chipid.c
  group sam_drivers_rtt
    ../../../../../sam/drivers/rtt/: rtt.c
  group sam_drivers_rtc
    ../../../../../sam/drivers/rtc/: rtc.c
  group sam_drivers_slcdc
    ../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_pmc_pic32cx
    ../../../../../sam/drivers/pmc/pic32cx/: sleep.c pmc.c
  group sam_drivers_dwdt
    ../../../../../sam/drivers/dwdt/: dwdt.c
  group sam_drivers_pio_pic32cx
    ../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_icm
    ../../../../../sam/drivers/icm/: icm.c
  group sam_drivers_uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_pdc
    ../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_qspi_pic32cx
    ../../../../../sam/drivers/qspi/pic32cx/: qspi.c
  group sam_drivers_flexcom
    ../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_efc
    ../../../../../sam/drivers/efc/: efc.c
  group sam_drivers_gpbr
    ../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_rstc
    ../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_ipc
    ../../../../../sam/drivers/ipc/: ipc.c
  group sam_drivers_usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_matrix_pic32cx
    ../../../../../sam/drivers/matrix/pic32cx/: matrix.c
  group sam_boards_pic32cxmtc_db
    ../../../../../sam/boards/pic32cxmtc_db/: init.c
  group sam_components_display_cl010
    ../../../../../sam/components/display/cl010/: cl010_slcdc.c
  group thirdparty_metrology_demo_meter
    ../../: main.c
  group thirdparty_metrology_demo_app_kenerl
    ../../../demo_app/kenerl/: task.c
  group thirdparty_metrology_demo_app_tou
    ../../../demo_app/tou/: tou.c
  group thirdparty_metrology_demo_app_rtcproc
    ../../../demo_app/rtcproc/: rtcproc.c
  group thirdparty_metrology_demo_app_utils
    ../../../demo_app/utils/: utils.c
  group thirdparty_metrology_demo_app_basetimer
    ../../../demo_app/basetimer/: basetime.c
  group thirdparty_metrology_demo_app_energy
    ../../../demo_app/energy/: energy.c
  group thirdparty_metrology_demo_app_metrology
    ../../../demo_app/metrology/: metrology.c
  group thirdparty_metrology_demo_app_command
    ../../../demo_app/command/: command.c
  group thirdparty_metrology_demo_app_coproc
    ../../../demo_app/coproc/: coproc.c
  group thirdparty_metrology_demo_app_demand
    ../../../demo_app/demand/: demand.c
  group thirdparty_metrology_demo_app_event
    ../../../demo_app/event/: event.c
  group thirdparty_metrology_demo_app_history
    ../../../demo_app/history/: history.c
  group thirdparty_metrology_demo_app_extmem
    ../../../demo_app/extmem/: extmem.c
  group thirdparty_metrology_demo_app_display
    ../../../demo_app/display/: display.c
  group thirdparty_metrology_demo_app_presskey
    ../../../demo_app/presskey/: presskey.c
  group common_services_sleepmgr_sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_delay_sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_clock_pic32cx
    ../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_services_serial
    ../../../../../common/services/serial/: usart_serial.c
  group common_components_memory_qspi_flash_sst26vfxxx
    ../../../../../common/components/memory/qspi_flash/sst26vfxxx/: sst26vfxxx.c
  group common_utils_stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
