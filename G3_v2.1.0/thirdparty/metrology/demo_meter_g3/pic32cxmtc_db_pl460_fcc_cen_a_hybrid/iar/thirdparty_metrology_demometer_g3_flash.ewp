# IAR project thirdparty_metrology_demometer_g3_flash.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: PIC32CX2051MTC128 Microchip PIC32CX2051MTC128 Core 0
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __G3_STACK__; BOARD=PIC32CXMTC_DB; __RF_MAC__; __PIC32CX2051MTC128__; ARM_MATH_CM4=true; __PLC_MAC__
  ICCARM.CCIncludePath2: ..\..\..\..\..\common\services\clock; ..\..\..\..\g3\routing_wrapper\source; ..\..\..\..\..\sam\services\plc\usi; ..\..\..\..\..\common\services\ioport; ..\..\..\..\g3\phy\atpl360\coup_tx_config; ..\..\..\..\..\sam\drivers\chipid; ..\..\..\..\cycloneTCP\cyclone_crypto; ..\..\..\..\..\sam\boards; ..\..\..\..\..\sam\services\plc\buart_if; ..\..\..\..\..\sam\drivers\gpbr; ..\..\..\demo_app\metrology; ..\..\..\..\..\common\utils; ..\..\..\..\g3\pal\atpl360_g3macrt\include; ..\..\..\..\g3\pal_rf\rf215_g3mac\include; ..\..\..\..\..\sam\components\display\cl010; ..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt; ..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx; ..\..\..\..\g3\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a; ..; ..\..\..\..\mbed-tls\include; ..\..\..\demo_app\coproc; ..\..\..\..\..\common\utils\stdio\stdio_serial; ..\..\..\..\..\sam\services\flash_efc; ..\..\..\..\cycloneTCP\common; ..\..\..\..\..\sam\utils\cmsis\pic32cx\include; ..\..\..\..\..\sam\drivers\spi; ..\..\..\demo_app\presskey; ..\..\..\..\..\sam\boards\pic32cxmtc_db; ..\..\..\..\..\sam\utils; ..\..\..\..\g3\routing_loadng\source; ..\..\..\..\g3\mac_rt\include; ..\..\..\..\..\sam\drivers\aes; ..\..\..\..\..\sam\drivers\pdc; ..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates; ..\..\..\..\g3\common\source; ..\..\..\..\..\common\components\rf\at86rf215\rf215_pll; ..\..\..\..\..\sam\drivers\adc; ..\..\..\demo_app\basetimer; ..\..\..\..\cycloneTCP\cyclone_tcp; ..\..\..\demo_app\energy; ..\..\..\demo_app\tou; ..\..\..\..\..\sam\drivers\ipc; ..\..\..\demo_app; ..\..\..\..\g3\oss; ..\..\..\..\..\sam\drivers\flexcom; ..\..\..\..\..\sam\drivers\pmc\pic32cx; ..\..\..\..\..\sam\drivers\trng; ..\..\..\..\..\sam\drivers\pio\pic32cx; ..\..\..\..\..\sam\utils\header_files; ..\..\..\..\g3; ..\..\..\..\cycloneTCP\module_config; ..\..\..\demo_app\demand; ..\..\..\..\..\sam\drivers\sfr; ..\..\..\..\..\common\services\serial; ..\..\..\..\..\sam\services\plc\busart_if; ..\..\..\demo_app\kenerl; ..\..\..\..\..\sam\drivers\rstc; ..\..\..\..\..\sam\services\plc\pcrc; ..\..\..\..\g3\adp\include; ..\..\..\..\..\sam\drivers\slcdc; ..\..\..\..\g3\routing_wrapper\include; ..\..\..\..\..\sam\drivers\rtc; ..\..\..\..\..\sam\drivers\supc\pic32cx; ..\..\..\..\..\common\components\rf\at86rf215\addons; ..\..\..\..\..\sam\drivers\cmcc; ..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3; ..\..\..\..\..\common\components\memory\qspi_flash\sst26vfxxx; ..\..\..\demo_app\history; ..\..\..\demo_app\rtcproc; ..\..\..\..\g3\mac\include; ..\..\..\demo_app\command; ..\..\..\..\dlms\server\profile_g3; ..\..\..\..\g3\common\include; ..\..\..\..\..\sam\drivers\efc; ..\..\..\..\..\common\components\rf\at86rf215\rf215_common; ..\..\..\..\cycloneTCP\atpl_extension; ..\..\..\..\g3\bootstrap_lbp\include; ..\..\..\..\..\common\services\sleepmgr; ..\..\..\..\..\sam\drivers\dwdt; ..\..\..\demo_app\extmem; ..\..\..\..\g3\phy\atpl360\coup_tx_config\coup_params; ..\..\..\..\..\sam\utils\fpu; ..\..\..\..\g3\routing_loadng\include; ..\..\..\..\..\sam\drivers\icm; ..\..\..\..\g3\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt; ..\..\..\..\g3\mac_common\include; ..\..\..\..\..\sam\drivers\rtt; ..\..\..\..\..\common\boards; ..\..\..\..\..\sam\drivers\tc; ..\..\..\demo_app\event; ..\..\..\..\..\sam\drivers\qspi\pic32cx; ..\..\..\..\..\common\components\rf\at86rf215\rf215_irq; ..\..\..\..\mbed-tls\sam_aes_alt; ..\..\..\demo_app\display; ..\..; ..\..\..\..\..\sam\utils\preprocessor; ..\..\..\..\..\common\services\delay; ..\..\..\..\dlms\server\lib; ..\..\..\..\..\common\services\serial\pic32cx_uart; ..\..\..\..\g3\bootstrap_lbp\source; ..\..\..\..\..\common\components\rf\at86rf215; ..\..\..\..\mbed-tls\library; ..\..\..\..\..\sam\drivers\uart; ..\..\..\..\..\sam\services\timer_1us; ..\..\..\..\..\sam\services\plc\pplc_if\atpl360; ..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc; ..\..\..\..\..\common\components\rf\at86rf215\rf215_fe; ..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt; ..\..\..\..\..\sam\drivers\matrix\pic32cx; ..\..\..\demo_app\utils; ..\..\..\..\..\sam\drivers\usart; ..\..\..\..\g3\mac_wrapper\include; ..\..\..\..\..\sam\services\rf\prf_if\at86rf215; ..\..\..\..\g3\mac_rf\include; .
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.ADefines: as above
  AARM.AUserIncludes: as above
  OBJCOPY.OOCOutputFile: thirdparty_metrology_demometer_g3_flash.bin
  ILINK.IlinkOutputFile: thirdparty_metrology_demometer_g3_flash.out
  ILINK.IlinkIcfFile: ..\..\..\..\..\sam\utils\linker_scripts\pic32cx\iar\pic32cx2051mtxx_0_flash.icf
  ILINK.IlinkExtraOptions: --image_input ..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_CENA.bin,atpl_bin_cena,P_atpl_bin_cena,8; --image_input ..\..\..\..\..\atpl\bin\ATPL360B_G3_MAC_RT_FCC.bin,atpl_bin_fcc,P_atpl_bin_fcc,8; --image_input ..\..\..\metrology_lib\core1_metlib.bin,core1_metlib,P_core1_metlib,8
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.FPU2: 0
  group thirdparty/dlms/libs/iar
    ../../../../dlms/libs/iar/: libsamM4-dlms-server-iar.a
  group thirdparty/dlms/server/profile_g3
    ../../../../dlms/server/profile_g3/: dlms_srv_data_example.c dlms_srv_data_example.h
  group thirdparty/dlms/server/lib
    ../../../../dlms/server/lib/: dlms_srv_cnf.h dlms_srv_types.h dlms_srv_lib.h
  group thirdparty/g3/libs/iar
    ../../../../g3/libs/iar/: lib-g3-iar-mac-rf.a lib-g3-iar-mac.a lib-g3-iar-loadng.a lib-g3-iar-adp.a
  group thirdparty/g3/storage
    ../../../../g3/storage/: storage.c storage.h
  group thirdparty/g3/common/source
    ../../../../g3/common/source/: Logger.c QueueMng.c Timer.c Random.c
  group thirdparty/g3/common/include
    ../../../../g3/common/include/: g3_stack_version.h Logger.h QueueMng.h Timer.h Random.h
  group thirdparty/g3/mac_wrapper/source
    ../../../../g3/mac_wrapper/source/: mac_wrapper.c
  group thirdparty/g3/mac_wrapper/include
    ../../../../g3/mac_wrapper/include/: mac_wrapper_defs.h mac_wrapper.h
  group thirdparty/g3/hal
    ../../../../g3/hal/: hal.h
  group thirdparty/g3/hal/SAM_atpl360
    ../../../../g3/hal/SAM_atpl360/: hal.c hal.h
  group thirdparty/g3/crypto
    ../../../../g3/crypto/: aes_wrapper.c cipher_wrapper.c eax.c mode_hdr.h cipher_wrapper.h eax.h aes_wrapper.h brg_types.h brg_endian.h
  group thirdparty/g3/mac_common/source
    ../../../../g3/mac_common/source/: MacCommon.c
  group thirdparty/g3/mac_common/include
    ../../../../g3/mac_common/include/: MacCommon.h MacCommonDefs.h
  group thirdparty/g3/routing_wrapper/source
    ../../../../g3/routing_wrapper/source/: RoutingWrapper.c
  group thirdparty/g3/routing_wrapper/include
    ../../../../g3/routing_wrapper/include/: RoutingTypes.h RoutingApi.h
  group thirdparty/g3/bootstrap_lbp/source
    ../../../../g3/bootstrap_lbp/source/: ProtoLbp.c ProcessLbpDev.c ProtoEapPsk.c ProtoLbp.h ProtoLbpVersion.h ProtoEapPsk.h
  group thirdparty/g3/bootstrap_lbp/include
    ../../../../g3/bootstrap_lbp/include/: LbpDefs.h ProcessLbpDev.h
  group thirdparty/g3/pal/atpl360_g3macrt/source
    ../../../../g3/pal/atpl360_g3macrt/source/: pal.c
  group thirdparty/g3/pal/atpl360_g3macrt/include
    ../../../../g3/pal/atpl360_g3macrt/include/: pal.h
  group thirdparty/g3/adp
    ../../../../g3/adp/: AdpConf.c
  group thirdparty/g3/adp/include
    ../../../../g3/adp/include/: AdpApi.h AdpSharedTypes.h AdpApiTypes.h
  group thirdparty/g3/oss
    ../../../../g3/oss/: oss_if.c oss_if.h
  group thirdparty/g3/pal_rf/rf215_g3mac/source
    ../../../../g3/pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty/g3/pal_rf/rf215_g3mac/include
    ../../../../g3/pal_rf/rf215_g3mac/include/: pal_rf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config
    ../../../../g3/phy/atpl360/coup_tx_config/: coup_tx_config.c coup_tx_config.h coup_defs.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a
    ../../../../g3/phy/atpl360/coup_tx_config/coup_conf/pl460_fcc_cen_a/: coup_conf.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt
    ../../../../g3/phy/atpl360/coup_tx_config/pl360_wrp/g3_mac_rt/: coup_pl360_wrp.h
  group thirdparty/g3/phy/atpl360/coup_tx_config/coup_params
    ../../../../g3/phy/atpl360/coup_tx_config/coup_params/: pl460_1_5b_fcc.h plcoup007_cen_a.h pl460_sb_fcc.h pl460_plcoup007_cen_a.h
  group thirdparty/g3/mac_rt/include
    ../../../../g3/mac_rt/include/: MacRtMib.h MacRtConstants.h MacRtDefs.h MacRt.h
  group thirdparty/g3/mac_rf/include
    ../../../../g3/mac_rf/include/: MacRfDefs.h MacRfApi.h MacRfMib.h
  group thirdparty/g3/mac/include
    ../../../../g3/mac/include/: MacMib.h MacApi.h MacDefs.h
  group thirdparty/g3/routing_loadng/include
    ../../../../g3/routing_loadng/include/: ProtoLoadNg.h
  group thirdparty/cycloneTCP/cyclone_tcp/ppp
    ../../../../cycloneTCP/cyclone_tcp/ppp/: ppp_debug.c ppp.c ppp_fsm.c ppp_hdlc.c ipv6cp.c ppp_misc.c lcp.c pap.c chap.c ppp_debug.h ppp_fsm.h ipcp.h ppp.h ppp_hdlc.h lcp.h ipv6cp.h ppp_misc.h pap.h chap.h
  group thirdparty/cycloneTCP/cyclone_tcp/core
    ../../../../cycloneTCP/cyclone_tcp/core/: nic.c ethernet_misc.c net_mem.c socket.c tcp_timer.c ip.c tcp.c udp.c ping.c net.c ethernet.c tcp_fsm.c raw_socket.c tcp_misc.c ethernet_misc.h tcp.h net.h nic.h ping.h socket.h tcp_timer.h ethernet.h udp.h net_mem.h ip.h tcp_fsm.h raw_socket.h net_legacy.h tcp_misc.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns
    ../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_client.c dns_debug.c dns_common.h dns_cache.h dns_client.h dns_debug.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv6
    ../../../../cycloneTCP/cyclone_tcp/ipv6/: ipv6_routing.c ndp.c ipv6.c ipv6_frag.c ipv6_misc.c icmpv6.c ndp_cache.c ndp_router_adv.c slaac.c ipv6_pmtu.c ndp_misc.c mld.c icmpv6.h ipv6_pmtu.h ndp_misc.h ndp_cache.h ipv6_misc.h mld.h ipv6_routing.h ndp.h ipv6.h slaac.h ipv6_frag.h ndp_router_adv.h
  group thirdparty/cycloneTCP/cyclone_tcp/mibs
    ../../../../cycloneTCP/cyclone_tcp/mibs/: tcp_mib_impl.c mib2_impl.c udp_mib_module.c udp_mib_impl.c ip_mib_module.c ip_mib_impl.c tcp_mib_module.c mib_common.c mib2_module.c tcp_mib_impl.h mib2_impl.h udp_mib_module.h ip_mib_impl.h tcp_mib_module.h mib2_module.h mib_common.h ip_mib_module.h udp_mib_impl.h if_mib_module.h
  group thirdparty/cycloneTCP/cyclone_tcp/mdns
    ../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c mdns_responder.h mdns_common.h mdns_client.h
  group thirdparty/cycloneTCP/cyclone_tcp/dns_sd
    ../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c dns_sd.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers
    ../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c plc_buart.h
  group thirdparty/cycloneTCP/cyclone_tcp/drivers/g3
    ../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c network_adapter_g3.h
  group thirdparty/cycloneTCP/cyclone_tcp/netbios
    ../../../../cycloneTCP/cyclone_tcp/netbios/: nbns_client.h nbns_common.h nbns_responder.h
  group thirdparty/cycloneTCP/cyclone_tcp/llmnr
    ../../../../cycloneTCP/cyclone_tcp/llmnr/: llmnr_responder.h llmnr_client.h llmnr_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcpv6
    ../../../../cycloneTCP/cyclone_tcp/dhcpv6/: dhcpv6_client.h dhcpv6_common.h
  group thirdparty/cycloneTCP/cyclone_tcp/ipv4
    ../../../../cycloneTCP/cyclone_tcp/ipv4/: ipv4_routing.h icmp.h arp.h auto_ip.h ipv4_misc.h ipv4.h igmp.h ipv4_frag.h
  group thirdparty/cycloneTCP/cyclone_tcp/dhcp
    ../../../../cycloneTCP/cyclone_tcp/dhcp/: dhcp_common.h dhcp_server.h dhcp_client.h
  group thirdparty/cycloneTCP/common
    ../../../../cycloneTCP/common/: os_port_none.c debug.c str.c date_time.c cpu_endian.c path.c os_port_none.h cpu_endian.h os_port.h error.h compiler_port.h fs_port.h debug.h date_time.h path.h str.h
  group thirdparty/cycloneTCP/cyclone_crypto/encoding
    ../../../../cycloneTCP/cyclone_crypto/encoding/: asn1.c oid.c asn1.h oid.h
  group thirdparty/cycloneTCP/cyclone_crypto/core
    ../../../../cycloneTCP/cyclone_crypto/core/: crypto.h crypto_legacy.h
  group thirdparty/cycloneTCP/cyclone_crypto/mpi
    ../../../../cycloneTCP/cyclone_crypto/mpi/: mpi.h
  group thirdparty/cycloneTCP/atpl_extension
    ../../../../cycloneTCP/atpl_extension/: async_ping.c async_ping.h
  group thirdparty/cycloneTCP/module_config
    ../../../../cycloneTCP/module_config/: crypto_config.h net_config.h os_port_config.h fs_port_config.h
  group thirdparty/mbed-tls/library
    ../../../../mbed-tls/library/: aes_tls.c aesni.c memory_buffer_alloc.c error.c ccm.c version_features.c cmac.c debug_tls.c timing.c platform.c version.c cipher.c gcm.c oid_tls.c platform_util.c cipher_wrap.c aesni.h common.h cipher_wrap.h
  group thirdparty/mbed-tls/sam_aes_alt
    ../../../../mbed-tls/sam_aes_alt/: aes_alt.c aes_alt.h
  group thirdparty/mbed-tls/include/mbedtls
    ../../../../mbed-tls/include/mbedtls/: compat-2.x.h gcm.h version.h oid.h aes.h build_info.h ctr_drbg.h ssl.h md.h mbedtls_config.h cmac.h bignum.h asn1.h platform_time.h private_access.h timing.h cipher.h platform_util.h check_config.h entropy.h debug.h platform.h ssl_ciphersuites.h threading.h pk.h memory_buffer_alloc.h ccm.h ecp.h error.h base64.h sha256.h
  group thirdparty/metrology/demo_app
    ../../../demo_app/: demo_app_version.h
  group thirdparty/metrology/demo_app/kenerl
    ../../../demo_app/kenerl/: task.c task.h
  group thirdparty/metrology/demo_app/command
    ../../../demo_app/command/: command.c command.h
  group thirdparty/metrology/demo_app/event
    ../../../demo_app/event/: event.c event.h
  group thirdparty/metrology/demo_app/extmem
    ../../../demo_app/extmem/: extmem.c extmem.h
  group thirdparty/metrology/demo_app/utils
    ../../../demo_app/utils/: utils.c utils.h
  group thirdparty/metrology/demo_app/coproc
    ../../../demo_app/coproc/: coproc.c coproc.h
  group thirdparty/metrology/demo_app/rtcproc
    ../../../demo_app/rtcproc/: rtcproc.c rtcproc.h
  group thirdparty/metrology/demo_app/tou
    ../../../demo_app/tou/: tou.c tou.h
  group thirdparty/metrology/demo_app/energy
    ../../../demo_app/energy/: energy.c energy.h
  group thirdparty/metrology/demo_app/demand
    ../../../demo_app/demand/: demand.c demand.h
  group thirdparty/metrology/demo_app/basetimer
    ../../../demo_app/basetimer/: basetime.c basetime.h
  group thirdparty/metrology/demo_app/metrology
    ../../../demo_app/metrology/: metrology.c metrology.h
  group thirdparty/metrology/demo_app/history
    ../../../demo_app/history/: history.c history.h
  group thirdparty/metrology/demo_app/display
    ../../../demo_app/display/: display.c display.h
  group thirdparty/metrology/demo_app/presskey
    ../../../demo_app/presskey/: presskey.c presskey.h
  group thirdparty/metrology/demo_meter_g3
    ../../: dlms_dev.c app_dispatcher.c main.c app_udp_responder.c app_ping_dev.c dlms_srv_data.c app_adp_mng.c ipv6_mng.c app_demo_meter.c app_adp_mng.h app_ping_dev.h main.h g3_app_config.h app_udp_responder.h dlms_srv_data.h dlms_dev.h ipv6_mng.h app_demo_meter.h app_dispatcher.h conf_global.h
  group thirdparty/metrology/demo_meter_g3/pic32cxmtc_db_pl460_fcc_cen_a_hybrid
    ../: conf_cl010_slcdc.h conf_tables.h conf_at86rf.h conf_timer_1us.h conf_busart_if.h conf_prf_if.h conf_hal.h conf_slcdc.h conf_demo_app.h conf_project.h conf_clock.h conf_buart_if.h conf_sleepmgr.h conf_pplc_if.h conf_atpl360.h conf_usi.h conf_oss.h conf_command_serial.h conf_board.h conf_uart_serial.h
  group thirdparty/metrology/demo_meter_g3/pic32cxmtc_db_pl460_fcc_cen_a_hybrid/iar
    ./: asf.h
  group common/components/rf/at86rf215
    ../../../../../common/components/rf/at86rf215/: at86rf215.c at86rf.h at86rf_defs.h ieee_15_4_sun_ofdm.h ieee_15_4_sun_fsk.h at86rf_version.h
  group common/components/rf/at86rf215/rf215_common
    ../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c rf215_trx_ctl.h rf215_conf_check.h rf215_spi.h rf215_phy_defs.h rf215_reg.h
  group common/components/rf/at86rf215/rf215_tx_rx
    ../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_tx.c rf215_rx.c rf215_tx_rx.h rf215_tx_rx_defs.h
  group common/components/rf/at86rf215/addons
    ../../../../../common/components/rf/at86rf215/addons/: rf215_addon.h
  group common/components/rf/at86rf215/addons/sniffer_if
    ../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
  group common/components/rf/at86rf215/addons/sniffer_if/g3
    ../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c rf215_sniffer_if.h
  group common/components/rf/at86rf215/rf215_bbc
    ../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c rf215_bbc.h rf215_bbc_defs.h
  group common/components/rf/at86rf215/rf215_irq
    ../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c rf215_irq_defs.h rf215_irq.h
  group common/components/rf/at86rf215/rf215_pll
    ../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c rf215_pll_defs.h rf215_pll.h
  group common/components/rf/at86rf215/rf215_fe
    ../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c rf215_fe_defs.h rf215_fe.h
  group common/components/plc/atpl360_g3_mac_rt
    ../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c atpl360_boot.c atpl360.c atpl360_hal_spi.h atpl360_boot.h atpl360_exception.h atpl360.h
  group common/components/plc/atpl360_g3_mac_rt/mac_rt
    ../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c atpl360_comm.h
  group common/components/memory/qspi_flash/sst26vfxxx
    ../../../../../common/components/memory/qspi_flash/sst26vfxxx/: sst26vfxxx.c sst26vfxxx.h
  group common/services/serial
    ../../../../../common/services/serial/: usart_serial.c serial.h
  group common/services/serial/pic32cx_uart
    ../../../../../common/services/serial/pic32cx_uart/: uart_serial.h
  group common/services/sleepmgr
    ../../../../../common/services/sleepmgr/: sleepmgr.h
  group common/services/sleepmgr/sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c sleepmgr.h
  group common/services/delay
    ../../../../../common/services/delay/: delay.h
  group common/services/delay/sam
    ../../../../../common/services/delay/sam/: cycle_counter.c cycle_counter.h
  group common/services/clock
    ../../../../../common/services/clock/: sysclk.h pll.h osc.h genclk.h
  group common/services/clock/pic32cx
    ../../../../../common/services/clock/pic32cx/: sysclk.c genclk.h osc.h sysclk.h pll.h
  group common/services/ioport
    ../../../../../common/services/ioport/: ioport.h
  group common/services/ioport/pic32cx
    ../../../../../common/services/ioport/pic32cx/: ioport_pio.h
  group common/utils
    ../../../../../common/utils/: interrupt.h parts.h
  group common/utils/stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common/utils/stdio/stdio_serial
    ../../../../../common/utils/stdio/stdio_serial/: stdio_serial.h
  group common/utils/interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c interrupt_sam_nvic.h
  group common/boards
    ../../../../../common/boards/: board.h
  group sam/drivers/flexcom
    ../../../../../sam/drivers/flexcom/: flexcom.c flexcom.h
  group sam/drivers/aes
    ../../../../../sam/drivers/aes/: aes.c aes.h
  group sam/drivers/aes/example
    ../../../../../sam/drivers/aes/example/: aes_example.h
  group sam/drivers/chipid
    ../../../../../sam/drivers/chipid/: chipid.c chipid.h
  group sam/drivers/qspi/pic32cx
    ../../../../../sam/drivers/qspi/pic32cx/: qspi.c qspi.h
  group sam/drivers/pdc
    ../../../../../sam/drivers/pdc/: pdc.c pdc.h
  group sam/drivers/trng
    ../../../../../sam/drivers/trng/: trng.c trng.h
  group sam/drivers/adc
    ../../../../../sam/drivers/adc/: adc.c adc.h
  group sam/drivers/rtc
    ../../../../../sam/drivers/rtc/: rtc.c rtc.h
  group sam/drivers/slcdc
    ../../../../../sam/drivers/slcdc/: slcdc.c slcdc.h
  group sam/drivers/pmc/pic32cx
    ../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c pmc.h sleep.h
  group sam/drivers/pio/pic32cx
    ../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c pio_handler.h pio.h
  group sam/drivers/icm
    ../../../../../sam/drivers/icm/: icm.c icm.h
  group sam/drivers/rstc
    ../../../../../sam/drivers/rstc/: rstc.c rstc.h
  group sam/drivers/usart
    ../../../../../sam/drivers/usart/: usart.c usart.h
  group sam/drivers/matrix/pic32cx
    ../../../../../sam/drivers/matrix/pic32cx/: matrix.c matrix.h
  group sam/drivers/tc
    ../../../../../sam/drivers/tc/: tc.c tc.h
  group sam/drivers/supc/pic32cx
    ../../../../../sam/drivers/supc/pic32cx/: supc.c supc.h
  group sam/drivers/cmcc
    ../../../../../sam/drivers/cmcc/: cmcc.c cmcc.h
  group sam/drivers/rtt
    ../../../../../sam/drivers/rtt/: rtt.c rtt.h
  group sam/drivers/uart
    ../../../../../sam/drivers/uart/: uart.c uart.h
  group sam/drivers/spi
    ../../../../../sam/drivers/spi/: spi.c spi.h
  group sam/drivers/gpbr
    ../../../../../sam/drivers/gpbr/: gpbr.c gpbr.h
  group sam/drivers/sfr
    ../../../../../sam/drivers/sfr/: sfr.c sfr.h
  group sam/drivers/ipc
    ../../../../../sam/drivers/ipc/: ipc.c ipc.h
  group sam/drivers/dwdt
    ../../../../../sam/drivers/dwdt/: dwdt.c dwdt.h
  group sam/drivers/efc
    ../../../../../sam/drivers/efc/: efc.c efc.h
  group sam/services/flash_efc
    ../../../../../sam/services/flash_efc/: flash_efc.c flash_efc.h
  group sam/services/plc/pplc_if/atpl360
    ../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c pplc_if.h
  group sam/services/plc/usi
    ../../../../../sam/services/plc/usi/: usi.c usi.h
  group sam/services/plc/busart_if
    ../../../../../sam/services/plc/busart_if/: busart_if.c busart_if.h
  group sam/services/plc/buart_if
    ../../../../../sam/services/plc/buart_if/: buart_if.c buart_if.h
  group sam/services/plc/pcrc
    ../../../../../sam/services/plc/pcrc/: pcrc.c pcrc.h
  group sam/services/timer_1us
    ../../../../../sam/services/timer_1us/: timer_1us.c timer_1us_hal.h timer_1us.h
  group sam/services/timer_1us/hal_pic32cx
    ../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam/services/rf/prf_if/at86rf215
    ../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c prf_if.h
  group sam/utils
    ../../../../../sam/utils/: compiler.h status_codes.h
  group sam/utils/cmsis/pic32cx/source/templates
    ../../../../../sam/utils/cmsis/pic32cx/source/templates/: system_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/source/templates/iar
    ../../../../../sam/utils/cmsis/pic32cx/source/templates/iar/: startup_pic32cxmt.c
  group sam/utils/cmsis/pic32cx/include
    ../../../../../sam/utils/cmsis/pic32cx/include/: system_pic32cxmt.h pic32cx5112mtsh128.h pic32cx2051mtg128.h pic32cx1025mtg128.h pic32cx2051mtg64.h pic32cx2051mtc128.h pic32cx1025mtsh128.h pic32cx5112mtg128.h pic32cx1025mtg64.h pic32cx2051mtsh128S1.h pic32cx1025mtsh128S1.h pic32cx5112mtc128S1.h pic32cx2051mtsh128.h pic32cx2051mtc128S1.h pic32cx1025mtc128S1.h pic32cx5112mtc128.h pic32cxmt.h pic32cx1025mtc128.h pic32cx5112mtsh128S1.h
  group sam/utils/cmsis/pic32cx/include/instance
    ../../../../../sam/utils/cmsis/pic32cx/include/instance/: ipc1.h twi7.h twi3.h usart3.h twi1.h flexcom4.h twi5.h sefc1.h spi3.h rtc.h mem2mem1.h qspi.h uart.h sfrbu.h gpbr.h spi5.h spi7.h tc1.h emafe.h tc3.h sfr.h pio.h spi1.h matrix0.h matrix2.h flexcom6.h flexcom3.h flexcom1.h usart4.h acc.h rstc.h usart0.h usart6.h flexcom5.h flexcom7.h usart2.h aesb.h sefc0.h aes.h trng.h cmcc0.h ipc0.h chipid.h twi6.h twi0.h twi4.h twi2.h mcspi.h rtt.h tc0.h tc2.h sha.h spi2.h mem2mem0.h icm.h spi4.h spi6.h syscwp.h cpkcc.h pmc.h dwdt.h spi0.h matrix3.h pwm.h matrix1.h adc.h supc.h flexcom2.h slcdc.h flexcom0.h usart5.h cmcc1.h usart1.h usart7.h
  group sam/utils/cmsis/pic32cx/include/component
    ../../../../../sam/utils/cmsis/pic32cx/include/component/: adc.h sfr.h cmcc.h icm.h rtt.h twi.h dwdt.h trng.h gpbr.h mem2mem.h acc.h mcspi.h chipid.h cpkcc.h qspi.h spi.h aes.h sha.h pio.h pmc.h ipc.h uart.h syscwp.h rtc.h sfrbu.h aesb.h sefc.h flexcom.h emafe.h pwm.h rstc.h usart.h matrix.h slcdc.h supc.h pdc.h tc.h
  group sam/utils/cmsis/pic32cx/include/pio
    ../../../../../sam/utils/cmsis/pic32cx/include/pio/: pic32cx5112mtg128.h pic32cx1025mtc128.h pic32cx5112mtsh128.h pic32cx5112mtc128.h pic32cx2051mtsh128.h pic32cx2051mtg64.h pic32cx2051mtc128.h pic32cx1025mtg64.h pic32cx1025mtg128.h pic32cx2051mtg128.h pic32cx1025mtsh128.h
  group sam/utils/preprocessor
    ../../../../../sam/utils/preprocessor/: mrepeat.h preprocessor.h tpaste.h stringz.h
  group sam/utils/fpu
    ../../../../../sam/utils/fpu/: fpu.h
  group sam/utils/header_files
    ../../../../../sam/utils/header_files/: io.h
  group sam/boards/pic32cxmtc_db
    ../../../../../sam/boards/pic32cxmtc_db/: init.c pic32cxmtc_db.h led.h
  group sam/components/display/cl010
    ../../../../../sam/components/display/cl010/: cl010_slcdc.c cl010.h cl010_font.h cl010_segmap.h
