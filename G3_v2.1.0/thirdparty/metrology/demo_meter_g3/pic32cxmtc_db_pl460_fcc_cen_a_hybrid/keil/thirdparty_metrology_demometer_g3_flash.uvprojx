# Keil uVision project thirdparty_metrology_demometer_g3_flash.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: PIC32CX2051MTC128 Microchip
  pack: Microchip.PIC32CX-MT_DFP-1.0.4
  cpu: IRAM(0x20000000,0x00080000) IRAM2(0x20080000,0x00008000) IRAM3(0x20088000,0x00004000) IROM(0x01000000,0x00100000) IROM2(0x01100000,0x00100000) IROM3(0x11000000,0x00100000) IROM4(0x11100000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: thirdparty_metrology_demometer_g3_flash
  c flags: Optim=1 oTime=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: __G3_STACK__ BOARD=PIC32CXMTC_DB __RF_MAC__ __PIC32CX2051MTC128__ ARM_MATH_CM4=true __PLC_MAC__
  c misc: --diag_suppress=66
  c include: ..\..\..\..\..\common\services\clock;..\..\..\..\g3\routing_wrapper\source;..\..\..\..\..\sam\services\plc\usi;..\..\..\..\..\common\services\ioport;..\..\..\..\g3\phy\atpl360\coup_tx_config;..\..\..\..\..\sam\drivers\chipid;..\..\..\..\cycloneTCP\cyclone_crypto;..\..\..\..\..\sam\boards;..\..\..\..\..\sam\services\plc\buart_if;..\..\..\..\..\sam\drivers\gpbr;..\..\..\demo_app\metrology;..\..\..\..\..\common\utils;..\..\..\..\g3\pal\atpl360_g3macrt\include;..\..\..\..\g3\pal_rf\rf215_g3mac\include;..\..\..\..\..\sam\components\display\cl010;..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt;..\..\..\..\..\common\components\rf\at86rf215\rf215_tx_rx;..\..\..\..\g3\phy\atpl360\coup_tx_config\coup_conf\pl460_fcc_cen_a;..;..\..\..\..\mbed-tls\include;..\..\..\demo_app\coproc;..\..\..\..\..\common\utils\stdio\stdio_serial;..\..\..\..\..\sam\services\flash_efc;..\..\..\..\cycloneTCP\common;..\..\..\..\..\sam\utils\cmsis\pic32cx\include;..\..\..\..\..\sam\drivers\spi;..\..\..\demo_app\presskey;..\..\..\..\..\sam\boards\pic32cxmtc_db;..\..\..\..\..\sam\utils;..\..\..\..\g3\routing_loadng\source;..\..\..\..\g3\mac_rt\include;..\..\..\..\..\sam\drivers\aes;..\..\..\..\..\sam\drivers\pdc;..\..\..\..\..\sam\utils\cmsis\pic32cx\source\templates;..\..\..\..\g3\common\source;..\..\..\..\..\common\components\rf\at86rf215\rf215_pll;..\..\..\..\..\sam\drivers\adc;..\..\..\demo_app\basetimer;..\..\..\..\cycloneTCP\cyclone_tcp;..\..\..\demo_app\energy;..\..\..\demo_app\tou;..\..\..\..\..\sam\drivers\ipc;..\..\..\demo_app;..\..\..\..\g3\oss;..\..\..\..\..\sam\drivers\flexcom;..\..\..\..\..\sam\drivers\pmc\pic32cx;..\..\..\..\..\sam\drivers\trng;..\..\..\..\..\sam\drivers\pio\pic32cx;..\..\..\..\..\sam\utils\header_files;..\..\..\..\g3;..\..\..\..\cycloneTCP\module_config;..\..\..\demo_app\demand;..\..\..\..\..\sam\drivers\sfr;..\..\..\..\..\common\services\serial;..\..\..\..\..\sam\services\plc\busart_if;..\..\..\demo_app\kenerl;..\..\..\..\..\sam\drivers\rstc;..\..\..\..\..\sam\services\plc\pcrc;..\..\..\..\g3\adp\include;..\..\..\..\..\sam\drivers\slcdc;..\..\..\..\g3\routing_wrapper\include;..\..\..\..\..\sam\drivers\rtc;..\..\..\..\..\sam\drivers\supc\pic32cx;..\..\..\..\..\common\components\rf\at86rf215\addons;..\..\..\..\..\sam\drivers\cmcc;..\..\..\..\..\common\components\rf\at86rf215\addons\sniffer_if\g3;..\..\..\..\..\common\components\memory\qspi_flash\sst26vfxxx;..\..\..\demo_app\history;..\..\..\demo_app\rtcproc;..\..\..\..\g3\mac\include;..\..\..\demo_app\command;..\..\..\..\dlms\server\profile_g3;..\..\..\..\g3\common\include;..\..\..\..\..\sam\drivers\efc;..\..\..\..\..\common\components\rf\at86rf215\rf215_common;..\..\..\..\cycloneTCP\atpl_extension;..\..\..\..\g3\bootstrap_lbp\include;..\..\..\..\..\common\services\sleepmgr;..\..\..\..\..\sam\drivers\dwdt;..\..\..\demo_app\extmem;..\..\..\..\g3\phy\atpl360\coup_tx_config\coup_params;..\..\..\..\..\sam\utils\fpu;..\..\..\..\g3\routing_loadng\include;..\..\..\..\..\sam\drivers\icm;..\..\..\..\g3\phy\atpl360\coup_tx_config\pl360_wrp\g3_mac_rt;..\..\..\..\g3\mac_common\include;..\..\..\..\..\sam\drivers\rtt;..\..\..\..\..\common\boards;..\..\..\..\..\sam\drivers\tc;..\..\..\demo_app\event;..\..\..\..\..\sam\drivers\qspi\pic32cx;..\..\..\..\..\common\components\rf\at86rf215\rf215_irq;..\..\..\..\mbed-tls\sam_aes_alt;..\..\..\demo_app\display;..\..;..\..\..\..\..\sam\utils\preprocessor;..\..\..\..\..\common\services\delay;..\..\..\..\dlms\server\lib;..\..\..\..\..\common\services\serial\pic32cx_uart;..\..\..\..\g3\bootstrap_lbp\source;..\..\..\..\..\common\components\rf\at86rf215;..\..\..\..\mbed-tls\library;..\..\..\..\..\sam\drivers\uart;..\..\..\..\..\sam\services\timer_1us;..\..\..\..\..\sam\services\plc\pplc_if\atpl360;..\..\..\..\..\common\components\rf\at86rf215\rf215_bbc;..\..\..\..\..\common\components\rf\at86rf215\rf215_fe;..\..\..\..\..\common\components\plc\atpl360_g3_mac_rt\mac_rt;..\..\..\..\..\sam\drivers\matrix\pic32cx;..\..\..\demo_app\utils;..\..\..\..\..\sam\drivers\usart;..\..\..\..\g3\mac_wrapper\include;..\..\..\..\..\sam\services\rf\prf_if\at86rf215;..\..\..\..\g3\mac_rf\include;.
  asm misc: --cpreproc
  asm include: as above
  memory RVCT4: ROM 0x1000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x8c000
  scatter file: .\pic32cxmt.sct
  group Startup
    ./: startup_pic32cxmt.s retarget.c system_pic32cxmt.c core1_metlib.S atpl_bin_multi.S
  group thirdparty_dlms_libs_keil
    ../../../../dlms/libs/keil/: libsamM4-dlms-server-keil.lib
  group thirdparty_dlms_server_profile_g3
    ../../../../dlms/server/profile_g3/: dlms_srv_data_example.c
  group thirdparty_g3_libs_keil
    ../../../../g3/libs/keil/: lib-g3-keil-mac-rf.lib lib-g3-keil-mac.lib lib-g3-keil-loadng.lib lib-g3-keil-adp.lib
  group thirdparty_g3_storage
    ../../../../g3/storage/: storage.c
  group thirdparty_g3_common_source
    ../../../../g3/common/source/: Logger.c QueueMng.c Timer.c Random.c
  group thirdparty_g3_mac_wrapper_source
    ../../../../g3/mac_wrapper/source/: mac_wrapper.c
  group thirdparty_g3_hal_SAM_atpl360
    ../../../../g3/hal/SAM_atpl360/: hal.c
  group thirdparty_g3_crypto
    ../../../../g3/crypto/: aes_wrapper.c cipher_wrapper.c eax.c
  group thirdparty_g3_mac_common_source
    ../../../../g3/mac_common/source/: MacCommon.c
  group thirdparty_g3_routing_wrapper_source
    ../../../../g3/routing_wrapper/source/: RoutingWrapper.c
  group thirdparty_g3_bootstrap_lbp_source
    ../../../../g3/bootstrap_lbp/source/: ProtoLbp.c ProcessLbpDev.c ProtoEapPsk.c
  group thirdparty_g3_pal_atpl360_g3macrt_source
    ../../../../g3/pal/atpl360_g3macrt/source/: pal.c
  group thirdparty_g3_adp
    ../../../../g3/adp/: AdpConf.c
  group thirdparty_g3_oss
    ../../../../g3/oss/: oss_if.c
  group thirdparty_g3_pal_rf_rf215_g3mac_source
    ../../../../g3/pal_rf/rf215_g3mac/source/: pal_rf.c
  group thirdparty_g3_phy_atpl360_coup_tx_config
    ../../../../g3/phy/atpl360/coup_tx_config/: coup_tx_config.c
  group thirdparty_cycloneTCP_cyclone_tcp_ppp
    ../../../../cycloneTCP/cyclone_tcp/ppp/: ppp_debug.c ppp.c ppp_fsm.c ppp_hdlc.c ipv6cp.c ppp_misc.c lcp.c pap.c chap.c
  group thirdparty_cycloneTCP_cyclone_tcp_core
    ../../../../cycloneTCP/cyclone_tcp/core/: nic.c ethernet_misc.c net_mem.c socket.c tcp_timer.c ip.c tcp.c udp.c ping.c net.c ethernet.c tcp_fsm.c raw_socket.c tcp_misc.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns
    ../../../../cycloneTCP/cyclone_tcp/dns/: dns_cache.c dns_common.c dns_client.c dns_debug.c
  group thirdparty_cycloneTCP_cyclone_tcp_ipv6
    ../../../../cycloneTCP/cyclone_tcp/ipv6/: ipv6_routing.c ndp.c ipv6.c ipv6_frag.c ipv6_misc.c icmpv6.c ndp_cache.c ndp_router_adv.c slaac.c ipv6_pmtu.c ndp_misc.c mld.c
  group thirdparty_cycloneTCP_cyclone_tcp_mibs
    ../../../../cycloneTCP/cyclone_tcp/mibs/: tcp_mib_impl.c mib2_impl.c udp_mib_module.c udp_mib_impl.c ip_mib_module.c ip_mib_impl.c tcp_mib_module.c mib_common.c mib2_module.c
  group thirdparty_cycloneTCP_cyclone_tcp_mdns
    ../../../../cycloneTCP/cyclone_tcp/mdns/: mdns_common.c mdns_responder.c mdns_client.c
  group thirdparty_cycloneTCP_cyclone_tcp_dns_sd
    ../../../../cycloneTCP/cyclone_tcp/dns_sd/: dns_sd.c
  group thirdparty_cycloneTCP_cyclone_tcp_drivers
    ../../../../cycloneTCP/cyclone_tcp/drivers/: plc_buart.c
    ../../../../cycloneTCP/cyclone_tcp/drivers/g3/: network_adapter_g3.c
  group thirdparty_cycloneTCP_common
    ../../../../cycloneTCP/common/: os_port_none.c debug.c str.c date_time.c cpu_endian.c path.c
  group thirdparty_cycloneTCP_cyclone_crypto_encoding
    ../../../../cycloneTCP/cyclone_crypto/encoding/: asn1.c oid.c
  group thirdparty_cycloneTCP_atpl_extension
    ../../../../cycloneTCP/atpl_extension/: async_ping.c
  group thirdparty_mbed-tls_library
    ../../../../mbed-tls/library/: aes_tls.c aesni.c memory_buffer_alloc.c error.c ccm.c version_features.c cmac.c debug_tls.c timing.c platform.c version.c cipher.c gcm.c oid_tls.c platform_util.c cipher_wrap.c
  group thirdparty_mbed-tls_sam_aes_alt
    ../../../../mbed-tls/sam_aes_alt/: aes_alt.c
  group metrology_demo_app_kenerl
    ../../../demo_app/kenerl/: task.c
  group metrology_demo_app_command
    ../../../demo_app/command/: command.c
  group metrology_demo_app_event
    ../../../demo_app/event/: event.c
  group metrology_demo_app_extmem
    ../../../demo_app/extmem/: extmem.c
  group metrology_demo_app_utils
    ../../../demo_app/utils/: utils.c
  group metrology_demo_app_coproc
    ../../../demo_app/coproc/: coproc.c
  group metrology_demo_app_rtcproc
    ../../../demo_app/rtcproc/: rtcproc.c
  group metrology_demo_app_tou
    ../../../demo_app/tou/: tou.c
  group metrology_demo_app_energy
    ../../../demo_app/energy/: energy.c
  group metrology_demo_app_demand
    ../../../demo_app/demand/: demand.c
  group metrology_demo_app_basetimer
    ../../../demo_app/basetimer/: basetime.c
  group metrology_demo_app_metrology
    ../../../demo_app/metrology/: metrology.c
  group metrology_demo_app_history
    ../../../demo_app/history/: history.c
  group metrology_demo_app_display
    ../../../demo_app/display/: display.c
  group metrology_demo_app_presskey
    ../../../demo_app/presskey/: presskey.c
  group metrology_demo_meter_g3
    ../../: dlms_dev.c app_dispatcher.c main.c app_udp_responder.c app_ping_dev.c dlms_srv_data.c app_adp_mng.c ipv6_mng.c app_demo_meter.c
  group common_components_rf_at86rf215_rf215_common
    ../../../../../common/components/rf/at86rf215/rf215_common/: rf215_spi.c rf215_trx_ctl.c
  group common_components_rf_at86rf215_rf215_tx_rx
    ../../../../../common/components/rf/at86rf215/rf215_tx_rx/: rf215_tx.c rf215_rx.c
  group common_components_rf_at86rf215_addons_sniffer_if
    ../../../../../common/components/rf/at86rf215/addons/sniffer_if/: rf215_sniffer_if.c
    ../../../../../common/components/rf/at86rf215/addons/sniffer_if/g3/: rf215_sniffer_if_g3.c
  group common_components_rf_at86rf215
    ../../../../../common/components/rf/at86rf215/: at86rf215.c
    ../../../../../common/components/rf/at86rf215/rf215_bbc/: rf215_bbc.c
  group common_components_rf_at86rf215_rf215_irq
    ../../../../../common/components/rf/at86rf215/rf215_irq/: rf215_irq.c
  group common_components_rf_at86rf215_rf215_pll
    ../../../../../common/components/rf/at86rf215/rf215_pll/: rf215_pll.c
  group common_components_rf_at86rf215_rf215_fe
    ../../../../../common/components/rf/at86rf215/rf215_fe/: rf215_fe.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_hal_spi.c
    ../../../../../common/components/plc/atpl360_g3_mac_rt/mac_rt/: atpl360_comm.c
  group common_components_plc_atpl360_g3_mac_rt
    ../../../../../common/components/plc/atpl360_g3_mac_rt/: atpl360_boot.c atpl360.c
  group common_components_memory_qspi_flash_sst26vfxxx
    ../../../../../common/components/memory/qspi_flash/sst26vfxxx/: sst26vfxxx.c
  group common_services_serial
    ../../../../../common/services/serial/: usart_serial.c
  group common_services_sleepmgr_sam
    ../../../../../common/services/sleepmgr/sam/: sleepmgr.c
  group common_services_delay_sam
    ../../../../../common/services/delay/sam/: cycle_counter.c
  group common_services_clock_pic32cx
    ../../../../../common/services/clock/pic32cx/: sysclk.c
  group common_utils_stdio
    ../../../../../common/utils/stdio/: write.c read.c
  group common_utils_interrupt
    ../../../../../common/utils/interrupt/: interrupt_sam_nvic.c
  group sam_drivers_flexcom
    ../../../../../sam/drivers/flexcom/: flexcom.c
  group sam_drivers_aes
    ../../../../../sam/drivers/aes/: aes.c
  group sam_drivers_chipid
    ../../../../../sam/drivers/chipid/: chipid.c
  group sam_drivers_qspi_pic32cx
    ../../../../../sam/drivers/qspi/pic32cx/: qspi.c
  group sam_drivers_pdc
    ../../../../../sam/drivers/pdc/: pdc.c
  group sam_drivers_trng
    ../../../../../sam/drivers/trng/: trng.c
  group sam_drivers_adc
    ../../../../../sam/drivers/adc/: adc.c
  group sam_drivers_rtc
    ../../../../../sam/drivers/rtc/: rtc.c
  group sam_drivers_slcdc
    ../../../../../sam/drivers/slcdc/: slcdc.c
  group sam_drivers_pmc_pic32cx
    ../../../../../sam/drivers/pmc/pic32cx/: pmc.c sleep.c
  group sam_drivers_pio_pic32cx
    ../../../../../sam/drivers/pio/pic32cx/: pio_handler.c pio.c
  group sam_drivers_icm
    ../../../../../sam/drivers/icm/: icm.c
  group sam_drivers_rstc
    ../../../../../sam/drivers/rstc/: rstc.c
  group sam_drivers_usart
    ../../../../../sam/drivers/usart/: usart.c
  group sam_drivers_matrix_pic32cx
    ../../../../../sam/drivers/matrix/pic32cx/: matrix.c
  group sam_drivers_tc
    ../../../../../sam/drivers/tc/: tc.c
  group sam_drivers_supc_pic32cx
    ../../../../../sam/drivers/supc/pic32cx/: supc.c
  group sam_drivers_cmcc
    ../../../../../sam/drivers/cmcc/: cmcc.c
  group sam_drivers_rtt
    ../../../../../sam/drivers/rtt/: rtt.c
  group sam_drivers_uart
    ../../../../../sam/drivers/uart/: uart.c
  group sam_drivers_spi
    ../../../../../sam/drivers/spi/: spi.c
  group sam_drivers_gpbr
    ../../../../../sam/drivers/gpbr/: gpbr.c
  group sam_drivers_sfr
    ../../../../../sam/drivers/sfr/: sfr.c
  group sam_drivers_ipc
    ../../../../../sam/drivers/ipc/: ipc.c
  group sam_drivers_dwdt
    ../../../../../sam/drivers/dwdt/: dwdt.c
  group sam_drivers_efc
    ../../../../../sam/drivers/efc/: efc.c
  group sam_services_flash_efc
    ../../../../../sam/services/flash_efc/: flash_efc.c
  group sam_services_plc_pplc_if_atpl360
    ../../../../../sam/services/plc/pplc_if/atpl360/: pplc_if.c
  group sam_services_plc_usi
    ../../../../../sam/services/plc/usi/: usi.c
  group sam_services_plc_busart_if
    ../../../../../sam/services/plc/busart_if/: busart_if.c
  group sam_services_plc_buart_if
    ../../../../../sam/services/plc/buart_if/: buart_if.c
  group sam_services_plc_pcrc
    ../../../../../sam/services/plc/pcrc/: pcrc.c
  group sam_services_timer_1us_hal_pic32cx
    ../../../../../sam/services/timer_1us/hal_pic32cx/: timer_1us_hal.c
  group sam_services_timer_1us
    ../../../../../sam/services/timer_1us/: timer_1us.c
  group sam_services_rf_prf_if_at86rf215
    ../../../../../sam/services/rf/prf_if/at86rf215/: prf_if.c
  group sam_boards_pic32cxmtc_db
    ../../../../../sam/boards/pic32cxmtc_db/: init.c
  group sam_components_display_cl010
    ../../../../../sam/components/display/cl010/: cl010_slcdc.c
software components: CMSIS:CORE 4.1.0, CMSIS:DSP 1.4.5
